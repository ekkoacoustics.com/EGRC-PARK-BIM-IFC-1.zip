Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-007 RAIL ASSEMBLY.SLDPRT.IFC
Time: 2024-12-17T11:46:38+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 13.0888319999999077; Volume Measure: 0.0130888319999999; Area Measure: 2.9033554629419589

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 13.0888319999999077; Volume Measure: 0.0130888319999999; Area Measure: 2.9033554629419589

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 13.0888319999999077; Volume Measure: 0.0130888319999999; Area Measure: 2.9033554629419589

# IfcBuildingElementProxy (8)
In: default BuildingStorey
Name
EGRC-PARK-007 RAIL ASSEMBLY.SLDPRT | PSet_Mass_Property - Mass Measure: 13.0888319999999077; Volume Measure: 0.0130888319999999; Area Measure: 2.9033554629419589
EGRC-PARK-008 CROSS CHANNEL PLATE
EGRC-PARK-008 CROSS CHANNEL PLATE-1
EGRC-PARK-008 CROSS CHANNEL PLATE-2
EGRC-PARK-008 CROSS CHANNEL PLATE-3
EGRC-PARK-014 CENTRAL CHANNEL
EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE
EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-1
