Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT.IFC
Time: 2024-12-17T11:48:02+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 25.6560000000004464; Volume Measure: 0.0256560000000004; Area Measure: 5.6677886055659155

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 25.6560000000004464; Volume Measure: 0.0256560000000004; Area Measure: 5.6677886055659155

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 25.6560000000004464; Volume Measure: 0.0256560000000004; Area Measure: 5.6677886055659155

# IfcBuildingElementProxy (22)
In: default BuildingStorey
Name
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT | PSet_Mass_Property - Mass Measure: 25.6560000000004464; Volume Measure: 0.0256560000000004; Area Measure: 5.6677886055659155
EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE
EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-1
EGRC-PARK-006 CROSS CHANNEL
EGRC-PARK-006 CROSS CHANNEL-1
EGRC-PARK-006 CROSS CHANNEL-2
EGRC-PARK-006 CROSS CHANNEL-3
EGRC-PARK-006 CROSS CHANNEL-4
EGRC-PARK-006 CROSS CHANNEL-5
EGRC-PARK-006 CROSS CHANNEL-6
EGRC-PARK-006 CROSS CHANNEL-7
EGRC-PARK-006 CROSS CHANNEL-8
EGRC-PARK-008 CROSS CHANNEL PLATE
EGRC-PARK-006 CROSS CHANNEL-9
EGRC-PARK-008 CROSS CHANNEL PLATE-1
EGRC-PARK-008 CROSS CHANNEL PLATE-2
EGRC-PARK-008 CROSS CHANNEL PLATE-3
EGRC-PARK-008 CROSS CHANNEL PLATE-4
EGRC-PARK-008 CROSS CHANNEL PLATE-5
EGRC-PARK-008 CROSS CHANNEL PLATE-6
EGRC-PARK-008 CROSS CHANNEL PLATE-7
EGRC-PARK-008 CROSS CHANNEL PLATE-8
