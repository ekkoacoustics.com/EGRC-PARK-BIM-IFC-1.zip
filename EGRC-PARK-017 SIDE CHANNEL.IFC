Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-017 SIDE CHANNEL.IFC
Time: 2024-12-17T11:13:06+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 24.7073280000002597; Volume Measure: 0.0247073280000003; Area Measure: 5.5002518956056603

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 24.7073280000002597; Volume Measure: 0.0247073280000003; Area Measure: 5.5002518956056603

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 24.7073280000002597; Volume Measure: 0.0247073280000003; Area Measure: 5.5002518956056603

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-PARK-017 SIDE CHANNEL | PSet_Mass_Property - Mass Measure: 24.7073280000002597; Volume Measure: 0.0247073280000003; Area Measure: 5.5002518956056603
EGRC-PARK-017 SIDE CHANNEL | SOLIDWORKS Custom Properties - DESCRIPTION: SIDE CHANNEL; PARTNUMBER: EGRC-PARK-017; REVISION: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE + ASSEMBLY; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
