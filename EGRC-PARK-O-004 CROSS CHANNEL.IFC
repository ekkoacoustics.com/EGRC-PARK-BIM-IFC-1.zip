Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-O-004 CROSS CHANNEL.IFC
Time: 2024-12-17T11:09:00+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 2.2198399999999991; Volume Measure: 0.0022198400000000; Area Measure: 0.4715420605565908

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 2.2198399999999991; Volume Measure: 0.0022198400000000; Area Measure: 0.4715420605565908

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 2.2198399999999991; Volume Measure: 0.0022198400000000; Area Measure: 0.4715420605565908

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-PARK-O-004 CROSS CHANNEL | PSet_Mass_Property - Mass Measure: 2.2198399999999991; Volume Measure: 0.0022198400000000; Area Measure: 0.4715420605565908
EGRC-PARK-O-004 CROSS CHANNEL
