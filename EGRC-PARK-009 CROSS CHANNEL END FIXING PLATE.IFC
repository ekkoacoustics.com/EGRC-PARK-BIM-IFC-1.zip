Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE.IFC
Time: 2024-12-17T11:22:03+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 0.2916479999999722; Volume Measure: 0.0002916480000000; Area Measure: 0.0623999999999971

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 0.2916479999999722; Volume Measure: 0.0002916480000000; Area Measure: 0.0623999999999971

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 0.2916479999999722; Volume Measure: 0.0002916480000000; Area Measure: 0.0623999999999971

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE | PSet_Mass_Property - Mass Measure: 0.2916479999999722; Volume Measure: 0.0002916480000000; Area Measure: 0.0623999999999971
EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE
