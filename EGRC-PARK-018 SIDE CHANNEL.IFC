Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-018 SIDE CHANNEL.IFC
Time: 2024-12-17T11:11:31+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 11.4358400000001321; Volume Measure: 0.0114358400000001; Area Measure: 2.5406571426239259

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 11.4358400000001321; Volume Measure: 0.0114358400000001; Area Measure: 2.5406571426239259

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 11.4358400000001321; Volume Measure: 0.0114358400000001; Area Measure: 2.5406571426239259

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-PARK-018 SIDE CHANNEL | PSet_Mass_Property - Mass Measure: 11.4358400000001321; Volume Measure: 0.0114358400000001; Area Measure: 2.5406571426239259
EGRC-PARK-018 SIDE CHANNEL
