Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-010 CAPPING PANEL.IFC
Time: 2024-12-17T11:21:01+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 6.8327040000000006; Volume Measure: 0.0068327040000000; Area Measure: 1.3572159999999998

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 6.8327040000000006; Volume Measure: 0.0068327040000000; Area Measure: 1.3572159999999998

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 6.8327040000000006; Volume Measure: 0.0068327040000000; Area Measure: 1.3572159999999998

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-PARK-010 CAPPING PANEL | PSet_Mass_Property - Mass Measure: 6.8327040000000006; Volume Measure: 0.0068327040000000; Area Measure: 1.3572159999999998
EGRC-PARK-010 CAPPING PANEL
