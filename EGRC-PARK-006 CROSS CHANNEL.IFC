Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-006 CROSS CHANNEL.IFC
Time: 2024-12-17T11:24:50+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 2.0246400000000246; Volume Measure: 0.0020246400000000; Area Measure: 0.4571420605565903

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 2.0246400000000246; Volume Measure: 0.0020246400000000; Area Measure: 0.4571420605565903

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 2.0246400000000246; Volume Measure: 0.0020246400000000; Area Measure: 0.4571420605565903

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-PARK-006 CROSS CHANNEL | PSet_Mass_Property - Mass Measure: 2.0246400000000246; Volume Measure: 0.0020246400000000; Area Measure: 0.4571420605565903
EGRC-PARK-006 CROSS CHANNEL
