Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-C-4X2-000 PARK CAPPED.SLDPRT.IFC
Time: 2024-12-17T16:37:27+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 114.6424140834915306; Volume Measure: 0.1146424140834916; Area Measure: 27.6311593255845622

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 114.6424140834915306; Volume Measure: 0.1146424140834916; Area Measure: 27.6311593255845622

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 114.6424140834915306; Volume Measure: 0.1146424140834916; Area Measure: 27.6311593255845622

# IfcBuildingElementProxy (192)
In: default BuildingStorey
Name | sets with these values | UNIT_OF_MEASURE
EGRC-PARK-C-4X2-000 PARK CAPPED.SLDPRT | PSet_Mass_Property - Mass Measure: 114.6424140834915306; Volume Measure: 0.1146424140834916; Area Measure: 27.6311593255845622
EGRC-PARK-001 END CHANNEL | 2 | SOLIDWORKS Custom Properties - DESCRIPTION: END CHANNEL; PARTNUMBER: EGRC-PARK-001; REVISION: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE + ASSEMBLY; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST
EGRC-PARK-001 CROSS RAIL ASSEMBLY.SLDPRT
3 x EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE
3 x EGRC-PARK-006 CROSS CHANNEL
3 x EGRC-PARK-006 CROSS CHANNEL-1
3 x EGRC-PARK-008 CROSS CHANNEL PLATE
3 x EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-1
EGRC-PARK-002 SIDE CHANNEL | 2 | SOLIDWORKS Custom Properties - DESCRIPTION: SIDE CHANNEL; PARTNUMBER: EGRC-PARK-002; REVISION: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE + ASSEMBLY; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-1
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-1
EGRC-PARK-005 CORNER
EGRC-PARK-005 CORNER-1
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-2
EGRC-PARK-001 CROSS RAIL ASSEMBLY.SLDPRT-1
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-3
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-2
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496-1
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-3
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-4
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-5
EGRC-PARK-010 CAPPING PANEL
EGRC-PARK-010 CAPPING PANEL-1
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-4
CROSS TEE RAIL SECTION
CROSS TEE RAIL SECTION-1
CROSS TEE RAIL SECTION-2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-5
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-6
CROSS TEE RAIL SECTION-3
CROSS TEE RAIL SECTION-4
EGRC-PARK-010 CAPPING PANEL-2
EGRC-PARK-010 CAPPING PANEL-3
Wire Cable +Snap Key Hook + Crimping
EGRC-PARK-010 CAPPING PANEL-4
Wire Cable +Snap Key Hook + Crimping-1
EGRC-PARK-010 CAPPING PANEL-5
Wire Cable +Snap Key Hook + Crimping-2
EGRC-PARK-010 CAPPING PANEL-6
Wire Cable +Snap Key Hook + Crimping-3
Wire Cable +Snap Key Hook + Crimping-4
Wire Cable +Snap Key Hook + Crimping-5
Wire Cable +Snap Key Hook + Crimping-6
Wire Cable +Snap Key Hook + Crimping-7
Wire Cable +Snap Key Hook + Crimping-8
Wire Cable +Snap Key Hook + Crimping-9
Wire Cable +Snap Key Hook + Crimping-10
Wire Cable +Snap Key Hook + Crimping-11
Wire Cable +Snap Key Hook + Crimping-12
Wire Cable +Snap Key Hook + Crimping-13
3.5mm Wood Screw Cross Head | 2 | - none -
3.5mm Wood Screw Cross Head-1 | 2 | - none -
3.5mm Wood Screw Cross Head-2 | 2 | - none -
3.5mm Wood Screw Cross Head-3 | 2 | - none -
3.5mm Wood Screw Cross Head-4 | 2 | - none -
3.5mm Wood Screw Cross Head-5 | 2 | - none -
3.5mm Wood Screw Cross Head-6 | 2 | - none -
3.5mm Wood Screw Cross Head-7 | 2 | - none -
3.5mm Wood Screw Cross Head-8 | 2 | - none -
3.5mm Wood Screw Cross Head-9 | 2 | - none -
3.5mm Wood Screw Cross Head-10 | 2 | - none -
3.5mm Wood Screw Cross Head-11 | 2 | - none -
3.5mm Wood Screw Cross Head-12 | 2 | - none -
3.5mm Wood Screw Cross Head-13 | 2 | - none -
3.5mm Wood Screw Cross Head-14 | 2 | - none -
3.5mm Wood Screw Cross Head-15 | 2 | - none -
3.5mm Wood Screw Cross Head-16 | 2 | - none -
3.5mm Wood Screw Cross Head-17 | 2 | - none -
3.5mm Wood Screw Cross Head-18 | 2 | - none -
3.5mm Wood Screw Cross Head-19 | 2 | - none -
3.5mm Wood Screw Cross Head-20 | 2 | - none -
3.5mm Wood Screw Cross Head-21 | 2 | - none -
3.5mm Wood Screw Cross Head-22 | 2 | - none -
3.5mm Wood Screw Cross Head-23 | 2 | - none -
3.5mm Wood Screw Cross Head-24 | 2 | - none -
3.5mm Wood Screw Cross Head-25 | 2 | - none -
3.5mm Wood Screw Cross Head-26 | 2 | - none -
3.5mm Wood Screw Cross Head-27 | 2 | - none -
3.5mm Wood Screw Cross Head-28 | 2 | - none -
3.5mm Wood Screw Cross Head-29 | 2 | - none -
3.5mm Wood Screw Cross Head-30 | 2 | - none -
3.5mm Wood Screw Cross Head-31 | 2 | - none -
3.5mm Wood Screw Cross Head-32 | 2 | - none -
3.5mm Wood Screw Cross Head-33 | 2 | - none -
3.5mm Wood Screw Cross Head-34 | 2 | - none -
3.5mm Wood Screw Cross Head-35 | 2 | - none -
3.5mm Wood Screw Cross Head-36 | 2 | - none -
3.5mm Wood Screw Cross Head-37 | 2 | - none -
3.5mm Wood Screw Cross Head-38 | 2 | - none -
3.5mm Wood Screw Cross Head-39 | 2 | - none -
3.5mm Wood Screw Cross Head-40 | 2 | - none -
3.5mm Wood Screw Cross Head-41 | 2 | - none -
3.5mm Wood Screw Cross Head-42 | 2 | - none -
3.5mm Wood Screw Cross Head-43 | 2 | - none -
3.5mm Wood Screw Cross Head-44 | 2 | - none -
3.5mm Wood Screw Cross Head-45 | 2 | - none -
3.5mm Wood Screw Cross Head-46 | 2 | - none -
3.5mm Wood Screw Cross Head-47 | 2 | - none -
3.5mm Wood Screw Cross Head-48 | 2 | - none -
3.5mm Wood Screw Cross Head-49 | 2 | - none -
3.5mm Wood Screw Cross Head-50 | 2 | - none -
3.5mm Wood Screw Cross Head-51 | 2 | - none -
3.5mm Wood Screw Cross Head-52 | 2 | - none -
3.5mm Wood Screw Cross Head-53 | 2 | - none -
3.5mm Wood Screw Cross Head-54 | 2 | - none -
3.5mm Wood Screw Cross Head-55 | 2 | - none -
3.5mm Wood Screw Cross Head-56 | 2 | - none -
3.5mm Wood Screw Cross Head-57 | 2 | - none -
3.5mm Wood Screw Cross Head-58 | 2 | - none -
3.5mm Wood Screw Cross Head-59 | 2 | - none -
3.5mm Wood Screw Cross Head-60 | 2 | - none -
3.5mm Wood Screw Cross Head-61 | 2 | - none -
3.5mm Wood Screw Cross Head-62 | 2 | - none -
3.5mm Wood Screw Cross Head-63 | 2 | - none -
3.5mm Wood Screw Cross Head-64 | 2 | - none -
3.5mm Wood Screw Cross Head-65 | 2 | - none -
3.5mm Wood Screw Cross Head-66 | 2 | - none -
3.5mm Wood Screw Cross Head-67 | 2 | - none -
3.5mm Wood Screw Cross Head-68 | 2 | - none -
3.5mm Wood Screw Cross Head-69 | 2 | - none -
3.5mm Wood Screw Cross Head-70 | 2 | - none -
3.5mm Wood Screw Cross Head-71 | 2 | - none -
EGRC-PARK-010 CAPPING PANEL-7
Wire Cable +Snap Key Hook + Crimping-14
3.5mm Wood Screw Cross Head-72 | 2 | - none -
EGRC-PARK-002 SIDE CHANNEL-1 | 2 | SOLIDWORKS Custom Properties - DESCRIPTION: SIDE CHANNEL; PARTNUMBER: EGRC-PARK-002; REVISION: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE + ASSEMBLY; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST
EGRC-PARK-005 CORNER-2
EGRC-PARK-001 CROSS RAIL ASSEMBLY.SLDPRT-2
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496-2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-7
CROSS TEE RAIL SECTION-5
EGRC-PARK-001 END CHANNEL-1 | 2 | SOLIDWORKS Custom Properties - DESCRIPTION: END CHANNEL; PARTNUMBER: EGRC-PARK-001; REVISION: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE + ASSEMBLY; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST
EGRC-PARK-002 RAIL ASSEMBLY.SLDPRT
EGRC-PARK-008 CROSS CHANNEL PLATE-3
EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-6
EGRC-PARK-008 CROSS CHANNEL PLATE-4
EGRC-PARK-003 CENTRAL CHANNEL
EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-7
EGRC-PARK-008 CROSS CHANNEL PLATE-5
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-8
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-6
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-9
EGRC-PARK-005 CORNER-3
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-7
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496-3
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-10
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-11
CROSS TEE RAIL SECTION-6
3.5mm Wood Screw Cross Head-73 | 2 | - none -
3.5mm Wood Screw Cross Head-74 | 2 | - none -
CROSS TEE RAIL SECTION-7
CROSS TEE RAIL SECTION-8
3.5mm Wood Screw Cross Head-75 | 2 | - none -
CROSS TEE RAIL SECTION-9
3.5mm Wood Screw Cross Head-76 | 2 | - none -
CROSS TEE RAIL SECTION-10
3.5mm Wood Screw Cross Head-77 | 2 | - none -
3.5mm Wood Screw Cross Head-78 | 2 | - none -
3.5mm Wood Screw Cross Head-79 | 2 | - none -
3.5mm Wood Screw Cross Head-80 | 2 | - none -
3.5mm Wood Screw Cross Head-81 | 2 | - none -
3.5mm Wood Screw Cross Head-82 | 2 | - none -
3.5mm Wood Screw Cross Head-83 | 2 | - none -
3.5mm Wood Screw Cross Head-84 | 2 | - none -
3.5mm Wood Screw Cross Head-85 | 2 | - none -
3.5mm Wood Screw Cross Head-86 | 2 | - none -
3.5mm Wood Screw Cross Head-87 | 2 | - none -
3.5mm Wood Screw Cross Head-88 | 2 | - none -
3.5mm Wood Screw Cross Head-89 | 2 | - none -
3.5mm Wood Screw Cross Head-90 | 2 | - none -
3.5mm Wood Screw Cross Head-91 | 2 | - none -
3.5mm Wood Screw Cross Head-92 | 2 | - none -
3.5mm Wood Screw Cross Head-93 | 2 | - none -
3.5mm Wood Screw Cross Head-94 | 2 | - none -
3.5mm Wood Screw Cross Head-95 | 2 | - none -
3.5mm Wood Screw Cross Head-96 | 2 | - none -
3.5mm Wood Screw Cross Head-97 | 2 | - none -
3.5mm Wood Screw Cross Head-98 | 2 | - none -
3.5mm Wood Screw Cross Head-99 | 2 | - none -
