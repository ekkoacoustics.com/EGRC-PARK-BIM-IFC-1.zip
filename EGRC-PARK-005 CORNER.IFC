Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-005 CORNER.IFC
Time: 2024-12-17T11:25:44+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 1.9774400000000014; Volume Measure: 0.0019774400000000; Area Measure: 0.4782189084683740

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 1.9774400000000014; Volume Measure: 0.0019774400000000; Area Measure: 0.4782189084683740

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 1.9774400000000014; Volume Measure: 0.0019774400000000; Area Measure: 0.4782189084683740

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-PARK-005 CORNER | PSet_Mass_Property - Mass Measure: 1.9774400000000014; Volume Measure: 0.0019774400000000; Area Measure: 0.4782189084683740
EGRC-PARK-005 CORNER
