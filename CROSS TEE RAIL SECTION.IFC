Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\CROSS TEE RAIL SECTION.IFC
Time: 2024-12-17T11:31:03+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 0.5433162325928363; Volume Measure: 0.0005433162325928; Area Measure: 1.5692467258642235

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 0.5433162325928363; Volume Measure: 0.0005433162325928; Area Measure: 1.5692467258642235

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 0.5433162325928363; Volume Measure: 0.0005433162325928; Area Measure: 1.5692467258642235

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
CROSS TEE RAIL SECTION | PSet_Mass_Property - Mass Measure: 0.5433162325928363; Volume Measure: 0.0005433162325928; Area Measure: 1.5692467258642235
CROSS TEE RAIL SECTION
