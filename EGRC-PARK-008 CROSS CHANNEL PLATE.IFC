Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-008 CROSS CHANNEL PLATE.IFC
Time: 2024-12-17T11:22:58+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 0.5362559999999914; Volume Measure: 0.0005362560000000; Area Measure: 0.1079519999999986

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 0.5362559999999914; Volume Measure: 0.0005362560000000; Area Measure: 0.1079519999999986

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 0.5362559999999914; Volume Measure: 0.0005362560000000; Area Measure: 0.1079519999999986

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-PARK-008 CROSS CHANNEL PLATE | PSet_Mass_Property - Mass Measure: 0.5362559999999914; Volume Measure: 0.0005362560000000; Area Measure: 0.1079519999999986
EGRC-PARK-008 CROSS CHANNEL PLATE
