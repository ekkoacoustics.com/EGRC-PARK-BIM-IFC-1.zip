Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\CROSS TEE RAIL.IFC
Time: 2024-12-17T11:30:03+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 0.0009091637091580; Volume Measure: 0.0000009091637092; Area Measure: 0.0028074433394260

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 0.0009091637091580; Volume Measure: 0.0000009091637092; Area Measure: 0.0028074433394260

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 0.0009091637091580; Volume Measure: 0.0000009091637092; Area Measure: 0.0028074433394260

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
CROSS TEE RAIL | PSet_Mass_Property - Mass Measure: 0.0009091637091580; Volume Measure: 0.0000009091637092; Area Measure: 0.0028074433394260
CROSS TEE RAIL
