Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-C-3X3-000 PARK CAPPED.SLDPRT.IFC
Time: 2024-12-17T16:38:50+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 126.4955915298203450; Volume Measure: 0.1264955915298197; Area Measure: 30.4475565981512091

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 126.4955915298203450; Volume Measure: 0.1264955915298197; Area Measure: 30.4475565981512091

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 126.4955915298203450; Volume Measure: 0.1264955915298197; Area Measure: 30.4475565981512091

# IfcBuildingElementProxy (202)
In: default BuildingStorey
Name | UNIT_OF_MEASURE | sets with these values
EGRC-PARK-C-3X3-000 PARK CAPPED.SLDPRT | PSet_Mass_Property - Mass Measure: 126.4955915298203450; Volume Measure: 0.1264955915298197; Area Measure: 30.4475565981512091
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-1
EGRC-PARK-003 RAIL ASSEMBLY.SLDPRT
2 x EGRC-PARK-013 CENTRAL CHANNEL
2 x EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE
2 x EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-1
2 x EGRC-PARK-008 CROSS CHANNEL PLATE
2 x EGRC-PARK-008 CROSS CHANNEL PLATE-1
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-1
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-3
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496-1
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-3
3.5mm Wood Screw Cross Head | - none - | 2
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496-2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-4
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-5
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-4
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-5
3.5mm Wood Screw Cross Head-1 | - none - | 2
3.5mm Wood Screw Cross Head-2 | - none - | 2
3.5mm Wood Screw Cross Head-3 | - none - | 2
3.5mm Wood Screw Cross Head-4 | - none - | 2
3.5mm Wood Screw Cross Head-5 | - none - | 2
3.5mm Wood Screw Cross Head-6 | - none - | 2
3.5mm Wood Screw Cross Head-7 | - none - | 2
3.5mm Wood Screw Cross Head-8 | - none - | 2
3.5mm Wood Screw Cross Head-9 | - none - | 2
3.5mm Wood Screw Cross Head-10 | - none - | 2
3.5mm Wood Screw Cross Head-11 | - none - | 2
3.5mm Wood Screw Cross Head-12 | - none - | 2
3.5mm Wood Screw Cross Head-13 | - none - | 2
3.5mm Wood Screw Cross Head-14 | - none - | 2
3.5mm Wood Screw Cross Head-15 | - none - | 2
3.5mm Wood Screw Cross Head-16 | - none - | 2
3.5mm Wood Screw Cross Head-17 | - none - | 2
3.5mm Wood Screw Cross Head-18 | - none - | 2
3.5mm Wood Screw Cross Head-19 | - none - | 2
3.5mm Wood Screw Cross Head-20 | - none - | 2
3.5mm Wood Screw Cross Head-21 | - none - | 2
3.5mm Wood Screw Cross Head-22 | - none - | 2
3.5mm Wood Screw Cross Head-23 | - none - | 2
3.5mm Wood Screw Cross Head-24 | - none - | 2
3.5mm Wood Screw Cross Head-25 | - none - | 2
3.5mm Wood Screw Cross Head-26 | - none - | 2
3.5mm Wood Screw Cross Head-27 | - none - | 2
3.5mm Wood Screw Cross Head-28 | - none - | 2
3.5mm Wood Screw Cross Head-29 | - none - | 2
3.5mm Wood Screw Cross Head-30 | - none - | 2
3.5mm Wood Screw Cross Head-31 | - none - | 2
3.5mm Wood Screw Cross Head-32 | - none - | 2
3.5mm Wood Screw Cross Head-33 | - none - | 2
3.5mm Wood Screw Cross Head-34 | - none - | 2
3.5mm Wood Screw Cross Head-35 | - none - | 2
3.5mm Wood Screw Cross Head-36 | - none - | 2
3.5mm Wood Screw Cross Head-37 | - none - | 2
3.5mm Wood Screw Cross Head-38 | - none - | 2
3.5mm Wood Screw Cross Head-39 | - none - | 2
3.5mm Wood Screw Cross Head-40 | - none - | 2
3.5mm Wood Screw Cross Head-41 | - none - | 2
3.5mm Wood Screw Cross Head-42 | - none - | 2
3.5mm Wood Screw Cross Head-43 | - none - | 2
3.5mm Wood Screw Cross Head-44 | - none - | 2
EGRC-PARK-012 END CHANNEL |  | 2 | SOLIDWORKS Custom Properties - DESCRIPTION: END CHANNEL; PARTNUMBER: EGRC-PARK-012; REVISION: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE + ASSEMBLY; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST
EGRC-PARK-003 RAIL ASSEMBLY.SLDPRT-1
EGRC-PARK-012 END CHANNEL-1 |  | 2 | SOLIDWORKS Custom Properties - DESCRIPTION: END CHANNEL; PARTNUMBER: EGRC-PARK-012; REVISION: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE + ASSEMBLY; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST
EGRC-PARK-005 CORNER
EGRC-PARK-004 CROSS RAIL ASSEMBLY.SLDPRT
2 x EGRC-PARK-006 CROSS CHANNEL
2 x EGRC-PARK-006 CROSS CHANNEL-1
2 x EGRC-PARK-008 CROSS CHANNEL PLATE-4
2 x EGRC-PARK-008 CROSS CHANNEL PLATE-5
2 x EGRC-PARK-006 CROSS CHANNEL-2
2 x EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-4
2 x EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-5
EGRC-PARK-005 CORNER-1
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-6
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-6
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-7
EGRC-PARK-011 SIDE CHANNEL
EGRC-PARK-005 CORNER-2
EGRC-PARK-005 CORNER-3
EGRC-PARK-011 SIDE CHANNEL-1
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496-3
EGRC-PARK-004 CROSS RAIL ASSEMBLY.SLDPRT-1
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-7
3.5mm Wood Screw Cross Head-45 | - none - | 2
3.5mm Wood Screw Cross Head-46 | - none - | 2
3.5mm Wood Screw Cross Head-47 | - none - | 2
3.5mm Wood Screw Cross Head-48 | - none - | 2
3.5mm Wood Screw Cross Head-49 | - none - | 2
3.5mm Wood Screw Cross Head-50 | - none - | 2
3.5mm Wood Screw Cross Head-51 | - none - | 2
3.5mm Wood Screw Cross Head-52 | - none - | 2
3.5mm Wood Screw Cross Head-53 | - none - | 2
3.5mm Wood Screw Cross Head-54 | - none - | 2
3.5mm Wood Screw Cross Head-55 | - none - | 2
3.5mm Wood Screw Cross Head-56 | - none - | 2
3.5mm Wood Screw Cross Head-57 | - none - | 2
3.5mm Wood Screw Cross Head-58 | - none - | 2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-8
3.5mm Wood Screw Cross Head-59 | - none - | 2
CROSS TEE RAIL SECTION
3.5mm Wood Screw Cross Head-60 | - none - | 2
3.5mm Wood Screw Cross Head-61 | - none - | 2
3.5mm Wood Screw Cross Head-62 | - none - | 2
3.5mm Wood Screw Cross Head-63 | - none - | 2
3.5mm Wood Screw Cross Head-64 | - none - | 2
3.5mm Wood Screw Cross Head-65 | - none - | 2
3.5mm Wood Screw Cross Head-66 | - none - | 2
3.5mm Wood Screw Cross Head-67 | - none - | 2
3.5mm Wood Screw Cross Head-68 | - none - | 2
3.5mm Wood Screw Cross Head-69 | - none - | 2
3.5mm Wood Screw Cross Head-70 | - none - | 2
CROSS TEE RAIL SECTION-1
CROSS TEE RAIL SECTION-2
CROSS TEE RAIL SECTION-3
EGRC-PARK-010 CAPPING PANEL
Wire Cable +Snap Key Hook + Crimping
Wire Cable +Snap Key Hook + Crimping-1
Wire Cable +Snap Key Hook + Crimping-2
Wire Cable +Snap Key Hook + Crimping-3
EGRC-PARK-010 CAPPING PANEL-1
EGRC-PARK-010 CAPPING PANEL-2
EGRC-PARK-010 CAPPING PANEL-3
EGRC-PARK-010 CAPPING PANEL-4
Wire Cable +Snap Key Hook + Crimping-4
Wire Cable +Snap Key Hook + Crimping-5
Wire Cable +Snap Key Hook + Crimping-6
EGRC-PARK-010 CAPPING PANEL-5
EGRC-PARK-010 CAPPING PANEL-6
Wire Cable +Snap Key Hook + Crimping-7
Wire Cable +Snap Key Hook + Crimping-8
Wire Cable +Snap Key Hook + Crimping-9
Wire Cable +Snap Key Hook + Crimping-10
Wire Cable +Snap Key Hook + Crimping-11
Wire Cable +Snap Key Hook + Crimping-12
Wire Cable +Snap Key Hook + Crimping-13
Wire Cable +Snap Key Hook + Crimping-14
Wire Cable +Snap Key Hook + Crimping-15
3.5mm Wood Screw Cross Head-71 | - none - | 2
3.5mm Wood Screw Cross Head-72 | - none - | 2
3.5mm Wood Screw Cross Head-73 | - none - | 2
3.5mm Wood Screw Cross Head-74 | - none - | 2
3.5mm Wood Screw Cross Head-75 | - none - | 2
3.5mm Wood Screw Cross Head-76 | - none - | 2
3.5mm Wood Screw Cross Head-77 | - none - | 2
3.5mm Wood Screw Cross Head-78 | - none - | 2
3.5mm Wood Screw Cross Head-79 | - none - | 2
3.5mm Wood Screw Cross Head-80 | - none - | 2
3.5mm Wood Screw Cross Head-81 | - none - | 2
3.5mm Wood Screw Cross Head-82 | - none - | 2
3.5mm Wood Screw Cross Head-83 | - none - | 2
3.5mm Wood Screw Cross Head-84 | - none - | 2
3.5mm Wood Screw Cross Head-85 | - none - | 2
3.5mm Wood Screw Cross Head-86 | - none - | 2
3.5mm Wood Screw Cross Head-87 | - none - | 2
3.5mm Wood Screw Cross Head-88 | - none - | 2
3.5mm Wood Screw Cross Head-89 | - none - | 2
3.5mm Wood Screw Cross Head-90 | - none - | 2
3.5mm Wood Screw Cross Head-91 | - none - | 2
3.5mm Wood Screw Cross Head-92 | - none - | 2
3.5mm Wood Screw Cross Head-93 | - none - | 2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-9
3.5mm Wood Screw Cross Head-94 | - none - | 2
3.5mm Wood Screw Cross Head-95 | - none - | 2
3.5mm Wood Screw Cross Head-96 | - none - | 2
3.5mm Wood Screw Cross Head-97 | - none - | 2
3.5mm Wood Screw Cross Head-98 | - none - | 2
3.5mm Wood Screw Cross Head-99 | - none - | 2
3.5mm Wood Screw Cross Head-100 | - none - | 2
3.5mm Wood Screw Cross Head-101 | - none - | 2
3.5mm Wood Screw Cross Head-102 | - none - | 2
3.5mm Wood Screw Cross Head-103 | - none - | 2
CROSS TEE RAIL SECTION-4
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-10
EGRC-PARK-010 CAPPING PANEL-7
EGRC-PARK-010 CAPPING PANEL-8
CROSS TEE RAIL SECTION-5
CROSS TEE RAIL SECTION-6
CROSS TEE RAIL SECTION-7
CROSS TEE RAIL SECTION-8
CROSS TEE RAIL SECTION-9
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-11
CROSS TEE RAIL SECTION-10
CROSS TEE RAIL SECTION-11
