Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-O-5X5-000 PARK OPEN.SLDPRT.IFC
Time: 2024-12-17T16:27:53+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 160.9078373876634487; Volume Measure: 0.1609078373876668; Area Measure: 44.7187708662757046

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 160.9078373876634487; Volume Measure: 0.1609078373876668; Area Measure: 44.7187708662757046

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 160.9078373876634487; Volume Measure: 0.1609078373876668; Area Measure: 44.7187708662757046

# IfcBuildingElementProxy (389)
In: default BuildingStorey
Name
EGRC-PARK-O-5X5-000 PARK OPEN.SLDPRT | PSet_Mass_Property - Mass Measure: 160.9078373876634487; Volume Measure: 0.1609078373876668; Area Measure: 44.7187708662757046
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-1
3.5mm Wood Screw Cross Head | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-1 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-2 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-2
3.5mm Wood Screw Cross Head-3 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-3
3.5mm Wood Screw Cross Head-4 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-5 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-6 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-7 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-8 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-9 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-10 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-11 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-12 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-13 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-14 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-15 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-16 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-17 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-18 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-19 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-20 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-21 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-22 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-23 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-24 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-25 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-26 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-27 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-28 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-29 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-30 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-31 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-32 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-33 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-34 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-35 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-36 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-37 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-38 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-39 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-40 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-41 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-42 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-43 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050
3.5mm Wood Screw Cross Head-44 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-45 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-1
3.5mm Wood Screw Cross Head-46 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-47 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-48 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-49 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-2
3.5mm Wood Screw Cross Head-50 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-51 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-52 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496-1
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496-2
3.5mm Wood Screw Cross Head-53 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
EGRC-PARK-005 CROSS RAIL ASSEMBLY.SLDPRT
4 x EGRC-PARK-008 CROSS CHANNEL PLATE
4 x EGRC-PARK-006 CROSS CHANNEL
4 x EGRC-PARK-008 CROSS CHANNEL PLATE-1
4 x EGRC-PARK-006 CROSS CHANNEL-1
4 x EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE
4 x EGRC-PARK-008 CROSS CHANNEL PLATE-2
4 x EGRC-PARK-006 CROSS CHANNEL-2
4 x EGRC-PARK-006 CROSS CHANNEL-3
4 x EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-1
4 x EGRC-PARK-006 CROSS CHANNEL-4
4 x EGRC-PARK-008 CROSS CHANNEL PLATE-3
EGRC-PARK-005 CROSS RAIL ASSEMBLY.SLDPRT-1
EGRC-PARK-005 CROSS RAIL ASSEMBLY.SLDPRT-2
CROSS TEE RAIL SECTION
CROSS TEE RAIL SECTION-1
EGRC-PARK-007 RAIL ASSEMBLY.SLDPRT
4 x EGRC-PARK-008 CROSS CHANNEL PLATE-12
4 x EGRC-PARK-008 CROSS CHANNEL PLATE-13
4 x EGRC-PARK-008 CROSS CHANNEL PLATE-14
4 x EGRC-PARK-014 CENTRAL CHANNEL
4 x EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-6
4 x EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-7
4 x EGRC-PARK-008 CROSS CHANNEL PLATE-15
CROSS TEE RAIL SECTION-2
CROSS TEE RAIL SECTION-3
CROSS TEE RAIL SECTION-4
EGRC-PARK-007 RAIL ASSEMBLY.SLDPRT-1
EGRC-PARK-007 RAIL ASSEMBLY.SLDPRT-2
CROSS TEE RAIL SECTION-5
CROSS TEE RAIL SECTION-6
CROSS TEE RAIL SECTION-7
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-4
3.5mm Wood Screw Cross Head-54 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-55 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-56 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-5
3.5mm Wood Screw Cross Head-57 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-58 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-59 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-60 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-6
3.5mm Wood Screw Cross Head-61 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-7
3.5mm Wood Screw Cross Head-62 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-63 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-64 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-65 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-8
3.5mm Wood Screw Cross Head-66 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-67 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-68 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-69 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-70 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-9
3.5mm Wood Screw Cross Head-71 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-72 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-73 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-74 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-75 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-76 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-77 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-78 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-79 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-80 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-81 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-82 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-83 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-84 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-85 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-86 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-87 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-88 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-89 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-90 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-91 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-92 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-93 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-94 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-10
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-11
3.5mm Wood Screw Cross Head-95 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-96 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-97 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-98 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-12
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-13
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-14
3.5mm Wood Screw Cross Head-99 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-100 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-3
3.5mm Wood Screw Cross Head-101 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
CROSS TEE RAIL SECTION-8
3.5mm Wood Screw Cross Head-102 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-103 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496-3
CROSS TEE RAIL SECTION-9
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-4
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-15
3.5mm Wood Screw Cross Head-104 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-105 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-106 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-107 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-108 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-109 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-110 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-111 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-112 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-113 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-114 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-115 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-116 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-117 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-118 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-119 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-120 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-5
Wire Cable +Snap Key Hook + Crimping
EGRC-PARK-005 CORNER
EGRC-PARK-007 RAIL ASSEMBLY.SLDPRT-3
EGRC-PARK-005 CROSS RAIL ASSEMBLY.SLDPRT-3
EGRC-PARK-018 SIDE CHANNEL
EGRC-PARK-005 CORNER-1
EGRC-PARK-018 SIDE CHANNEL-1
EGRC-PARK-005 CORNER-2
EGRC-PARK-005 CORNER-3
EGRC-PARK-018 SIDE CHANNEL-2
CROSS TEE RAIL SECTION-10
EGRC-PARK-018 SIDE CHANNEL-3
CROSS TEE RAIL SECTION-11
Wire Cable +Snap Key Hook + Crimping-1
Wire Cable +Snap Key Hook + Crimping-2
CROSS TEE RAIL SECTION-12
Wire Cable +Snap Key Hook + Crimping-3
CROSS TEE RAIL SECTION-13
CROSS TEE RAIL SECTION-14
CROSS TEE RAIL SECTION-15
Wire Cable +Snap Key Hook + Crimping-4
Wire Cable +Snap Key Hook + Crimping-5
CROSS TEE RAIL SECTION-16
Wire Cable +Snap Key Hook + Crimping-6
CROSS TEE RAIL SECTION-17
CROSS TEE RAIL SECTION-18
CROSS TEE RAIL SECTION-19
CROSS TEE RAIL SECTION-20
CROSS TEE RAIL SECTION-21
CROSS TEE RAIL SECTION-22
CROSS TEE RAIL SECTION-23
CROSS TEE RAIL SECTION-24
CROSS TEE RAIL SECTION-25
CROSS TEE RAIL SECTION-26
CROSS TEE RAIL SECTION-27
3.5mm Wood Screw Cross Head-121 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-122 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-6
3.5mm Wood Screw Cross Head-123 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-124 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-125 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-126 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-127 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-128 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-129 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-130 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-131 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-7
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-8
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-9
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-10
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-11
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-12
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-13
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-14
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-15
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-16
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-17
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-18
3.5mm Wood Screw Cross Head-132 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-133 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-19
3.5mm Wood Screw Cross Head-134 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-20
3.5mm Wood Screw Cross Head-135 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-21
3.5mm Wood Screw Cross Head-136 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-22
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-23
3.5mm Wood Screw Cross Head-137 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-138 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-139 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-140 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-141 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-142 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-143 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-144 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-145 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-146 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-147 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-148 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-149 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-150 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-151 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-152 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-153 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-154 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-155 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-156 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-157 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-158 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-159 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-160 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-161 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-162 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-163 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-164 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-165 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-166 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-167 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-168 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-169 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-170 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-171 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-172 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-173 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-174 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-175 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-176 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-177 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-178 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-179 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-180 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-181 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-182 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-183 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-184 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Wire Cable +Snap Key Hook + Crimping-7
Wire Cable +Snap Key Hook + Crimping-8
3.5mm Wood Screw Cross Head-185 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-186 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-187 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-188 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-189 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Wire Cable +Snap Key Hook + Crimping-9
3.5mm Wood Screw Cross Head-190 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Wire Cable +Snap Key Hook + Crimping-10
3.5mm Wood Screw Cross Head-191 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Wire Cable +Snap Key Hook + Crimping-11
Wire Cable +Snap Key Hook + Crimping-12
Wire Cable +Snap Key Hook + Crimping-13
Wire Cable +Snap Key Hook + Crimping-14
Wire Cable +Snap Key Hook + Crimping-15
Wire Cable +Snap Key Hook + Crimping-16
Wire Cable +Snap Key Hook + Crimping-17
Wire Cable +Snap Key Hook + Crimping-18
Wire Cable +Snap Key Hook + Crimping-19
Wire Cable +Snap Key Hook + Crimping-20
Wire Cable +Snap Key Hook + Crimping-21
Wire Cable +Snap Key Hook + Crimping-22
Wire Cable +Snap Key Hook + Crimping-23
Wire Cable +Snap Key Hook + Crimping-24
Wire Cable +Snap Key Hook + Crimping-25
Wire Cable +Snap Key Hook + Crimping-26
Wire Cable +Snap Key Hook + Crimping-27
Wire Cable +Snap Key Hook + Crimping-28
Wire Cable +Snap Key Hook + Crimping-29
Wire Cable +Snap Key Hook + Crimping-30
Wire Cable +Snap Key Hook + Crimping-31
Wire Cable +Snap Key Hook + Crimping-32
Wire Cable +Snap Key Hook + Crimping-33
Wire Cable +Snap Key Hook + Crimping-34
Wire Cable +Snap Key Hook + Crimping-35
