Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-O-10X10-000 PARK OPEN.SLDPRT.IFC
Time: 2024-12-17T16:25:56+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 996.2258088970831977; Volume Measure: 0.9962258088970575; Area Measure: 252.7155757154525872

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 996.2258088970831977; Volume Measure: 0.9962258088970575; Area Measure: 252.7155757154525872

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 996.2258088970831977; Volume Measure: 0.9962258088970575; Area Measure: 252.7155757154525872

# IfcBuildingElementProxy (1496)
In: default BuildingStorey
Name
EGRC-PARK-O-10X10-000 PARK OPEN.SLDPRT | PSet_Mass_Property - Mass Measure: 996.2258088970831977; Volume Measure: 0.9962258088970575; Area Measure: 252.7155757154525872
3.5mm Wood Screw Cross Head
3.5mm Wood Screw Cross Head-1
3.5mm Wood Screw Cross Head-2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-1
3.5mm Wood Screw Cross Head-3
3.5mm Wood Screw Cross Head-4
3.5mm Wood Screw Cross Head-5
3.5mm Wood Screw Cross Head-6
3.5mm Wood Screw Cross Head-7
3.5mm Wood Screw Cross Head-8
3.5mm Wood Screw Cross Head-9
3.5mm Wood Screw Cross Head-10
3.5mm Wood Screw Cross Head-11
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-2
3.5mm Wood Screw Cross Head-12
3.5mm Wood Screw Cross Head-13
3.5mm Wood Screw Cross Head-14
3.5mm Wood Screw Cross Head-15
3.5mm Wood Screw Cross Head-16
3.5mm Wood Screw Cross Head-17
3.5mm Wood Screw Cross Head-18
3.5mm Wood Screw Cross Head-19
3.5mm Wood Screw Cross Head-20
3.5mm Wood Screw Cross Head-21
3.5mm Wood Screw Cross Head-22
3.5mm Wood Screw Cross Head-23
3.5mm Wood Screw Cross Head-24
3.5mm Wood Screw Cross Head-25
3.5mm Wood Screw Cross Head-26
3.5mm Wood Screw Cross Head-27
3.5mm Wood Screw Cross Head-28
3.5mm Wood Screw Cross Head-29
3.5mm Wood Screw Cross Head-30
3.5mm Wood Screw Cross Head-31
3.5mm Wood Screw Cross Head-32
3.5mm Wood Screw Cross Head-33
3.5mm Wood Screw Cross Head-34
3.5mm Wood Screw Cross Head-35
3.5mm Wood Screw Cross Head-36
3.5mm Wood Screw Cross Head-37
3.5mm Wood Screw Cross Head-38
3.5mm Wood Screw Cross Head-39
3.5mm Wood Screw Cross Head-40
3.5mm Wood Screw Cross Head-41
3.5mm Wood Screw Cross Head-42
3.5mm Wood Screw Cross Head-43
3.5mm Wood Screw Cross Head-44
3.5mm Wood Screw Cross Head-45
3.5mm Wood Screw Cross Head-46
3.5mm Wood Screw Cross Head-47
3.5mm Wood Screw Cross Head-48
3.5mm Wood Screw Cross Head-49
3.5mm Wood Screw Cross Head-50
3.5mm Wood Screw Cross Head-51
3.5mm Wood Screw Cross Head-52
3.5mm Wood Screw Cross Head-53
3.5mm Wood Screw Cross Head-54
3.5mm Wood Screw Cross Head-55
3.5mm Wood Screw Cross Head-56
3.5mm Wood Screw Cross Head-57
3.5mm Wood Screw Cross Head-58
3.5mm Wood Screw Cross Head-59
3.5mm Wood Screw Cross Head-60
3.5mm Wood Screw Cross Head-61
3.5mm Wood Screw Cross Head-62
3.5mm Wood Screw Cross Head-63
3.5mm Wood Screw Cross Head-64
3.5mm Wood Screw Cross Head-65
3.5mm Wood Screw Cross Head-66
3.5mm Wood Screw Cross Head-67
3.5mm Wood Screw Cross Head-68
3.5mm Wood Screw Cross Head-69
3.5mm Wood Screw Cross Head-70
3.5mm Wood Screw Cross Head-71
3.5mm Wood Screw Cross Head-72
3.5mm Wood Screw Cross Head-73
3.5mm Wood Screw Cross Head-74
3.5mm Wood Screw Cross Head-75
3.5mm Wood Screw Cross Head-76
3.5mm Wood Screw Cross Head-77
3.5mm Wood Screw Cross Head-78
3.5mm Wood Screw Cross Head-79
3.5mm Wood Screw Cross Head-80
3.5mm Wood Screw Cross Head-81
3.5mm Wood Screw Cross Head-82
3.5mm Wood Screw Cross Head-83
3.5mm Wood Screw Cross Head-84
3.5mm Wood Screw Cross Head-85
3.5mm Wood Screw Cross Head-86
3.5mm Wood Screw Cross Head-87
3.5mm Wood Screw Cross Head-88
3.5mm Wood Screw Cross Head-89
3.5mm Wood Screw Cross Head-90
3.5mm Wood Screw Cross Head-91
3.5mm Wood Screw Cross Head-92
3.5mm Wood Screw Cross Head-93
3.5mm Wood Screw Cross Head-94
3.5mm Wood Screw Cross Head-95
3.5mm Wood Screw Cross Head-96
3.5mm Wood Screw Cross Head-97
3.5mm Wood Screw Cross Head-98
3.5mm Wood Screw Cross Head-99
3.5mm Wood Screw Cross Head-100
3.5mm Wood Screw Cross Head-101
3.5mm Wood Screw Cross Head-102
3.5mm Wood Screw Cross Head-103
3.5mm Wood Screw Cross Head-104
3.5mm Wood Screw Cross Head-105
3.5mm Wood Screw Cross Head-106
3.5mm Wood Screw Cross Head-107
3.5mm Wood Screw Cross Head-108
3.5mm Wood Screw Cross Head-109
3.5mm Wood Screw Cross Head-110
3.5mm Wood Screw Cross Head-111
3.5mm Wood Screw Cross Head-112
3.5mm Wood Screw Cross Head-113
3.5mm Wood Screw Cross Head-114
3.5mm Wood Screw Cross Head-115
3.5mm Wood Screw Cross Head-116
3.5mm Wood Screw Cross Head-117
3.5mm Wood Screw Cross Head-118
3.5mm Wood Screw Cross Head-119
3.5mm Wood Screw Cross Head-120
3.5mm Wood Screw Cross Head-121
3.5mm Wood Screw Cross Head-122
3.5mm Wood Screw Cross Head-123
3.5mm Wood Screw Cross Head-124
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-1
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-3
3.5mm Wood Screw Cross Head-125
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-4
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-5
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-6
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-7
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-8
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-9
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-10
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-11
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-12
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-13
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-14
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-15
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-16
3.5mm Wood Screw Cross Head-126
3.5mm Wood Screw Cross Head-127
3.5mm Wood Screw Cross Head-128
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-17
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-18
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-19
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-20
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-21
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-22
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-23
3.5mm Wood Screw Cross Head-129
3.5mm Wood Screw Cross Head-130
3.5mm Wood Screw Cross Head-131
3.5mm Wood Screw Cross Head-132
3.5mm Wood Screw Cross Head-133
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-3
3.5mm Wood Screw Cross Head-134
3.5mm Wood Screw Cross Head-135
3.5mm Wood Screw Cross Head-136
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-4
3.5mm Wood Screw Cross Head-137
3.5mm Wood Screw Cross Head-138
3.5mm Wood Screw Cross Head-139
3.5mm Wood Screw Cross Head-140
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-5
3.5mm Wood Screw Cross Head-141
3.5mm Wood Screw Cross Head-142
3.5mm Wood Screw Cross Head-143
3.5mm Wood Screw Cross Head-144
3.5mm Wood Screw Cross Head-145
3.5mm Wood Screw Cross Head-146
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496
3.5mm Wood Screw Cross Head-147
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496-1
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496-2
3.5mm Wood Screw Cross Head-148
3.5mm Wood Screw Cross Head-149
3.5mm Wood Screw Cross Head-150
EGRC-PARK-017 SIDE CHANNEL | SOLIDWORKS Custom Properties - DESCRIPTION: SIDE CHANNEL; PARTNUMBER: EGRC-PARK-017; REVISION: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE + ASSEMBLY; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
EGRC-PARK-017 SIDE CHANNEL-1 | SOLIDWORKS Custom Properties - DESCRIPTION: SIDE CHANNEL; PARTNUMBER: EGRC-PARK-017; REVISION: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE + ASSEMBLY; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
CROSS TEE RAIL SECTION
CROSS TEE RAIL SECTION-1
CROSS TEE RAIL SECTION-2
CROSS TEE RAIL SECTION-3
CROSS TEE RAIL SECTION-4
CROSS TEE RAIL SECTION-5
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT
25 x EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE
25 x EGRC-PARK-008 CROSS CHANNEL PLATE
25 x EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-1
25 x EGRC-PARK-006 CROSS CHANNEL
25 x EGRC-PARK-006 CROSS CHANNEL-1
25 x EGRC-PARK-006 CROSS CHANNEL-2
25 x EGRC-PARK-006 CROSS CHANNEL-3
25 x EGRC-PARK-006 CROSS CHANNEL-4
25 x EGRC-PARK-006 CROSS CHANNEL-5
25 x EGRC-PARK-006 CROSS CHANNEL-6
25 x EGRC-PARK-006 CROSS CHANNEL-7
25 x EGRC-PARK-006 CROSS CHANNEL-8
25 x EGRC-PARK-006 CROSS CHANNEL-9
25 x EGRC-PARK-008 CROSS CHANNEL PLATE-1
25 x EGRC-PARK-008 CROSS CHANNEL PLATE-2
25 x EGRC-PARK-008 CROSS CHANNEL PLATE-3
25 x EGRC-PARK-008 CROSS CHANNEL PLATE-4
25 x EGRC-PARK-008 CROSS CHANNEL PLATE-5
25 x EGRC-PARK-008 CROSS CHANNEL PLATE-6
25 x EGRC-PARK-008 CROSS CHANNEL PLATE-7
25 x EGRC-PARK-008 CROSS CHANNEL PLATE-8
CROSS TEE RAIL SECTION-6
CROSS TEE RAIL SECTION-7
CROSS TEE RAIL SECTION-8
CROSS TEE RAIL SECTION-9
CROSS TEE RAIL SECTION-10
CROSS TEE RAIL SECTION-11
CROSS TEE RAIL SECTION-12
CROSS TEE RAIL SECTION-13
CROSS TEE RAIL SECTION-14
CROSS TEE RAIL SECTION-15
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-1
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-2
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-3
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-4
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-5
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-6
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-7
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-8
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-9
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-10
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-11
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-12
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-13
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-14
Wire Cable +Snap Key Hook + Crimping
Wire Cable +Snap Key Hook + Crimping-1
Wire Cable +Snap Key Hook + Crimping-2
Wire Cable +Snap Key Hook + Crimping-3
Wire Cable +Snap Key Hook + Crimping-4
Wire Cable +Snap Key Hook + Crimping-5
Wire Cable +Snap Key Hook + Crimping-6
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-15
Wire Cable +Snap Key Hook + Crimping-7
Wire Cable +Snap Key Hook + Crimping-8
Wire Cable +Snap Key Hook + Crimping-9
Wire Cable +Snap Key Hook + Crimping-10
Wire Cable +Snap Key Hook + Crimping-11
Wire Cable +Snap Key Hook + Crimping-12
Wire Cable +Snap Key Hook + Crimping-13
Wire Cable +Snap Key Hook + Crimping-14
Wire Cable +Snap Key Hook + Crimping-15
Wire Cable +Snap Key Hook + Crimping-16
Wire Cable +Snap Key Hook + Crimping-17
Wire Cable +Snap Key Hook + Crimping-18
Wire Cable +Snap Key Hook + Crimping-19
Wire Cable +Snap Key Hook + Crimping-20
Wire Cable +Snap Key Hook + Crimping-21
Wire Cable +Snap Key Hook + Crimping-22
Wire Cable +Snap Key Hook + Crimping-23
Wire Cable +Snap Key Hook + Crimping-24
Wire Cable +Snap Key Hook + Crimping-25
Wire Cable +Snap Key Hook + Crimping-26
Wire Cable +Snap Key Hook + Crimping-27
Wire Cable +Snap Key Hook + Crimping-28
Wire Cable +Snap Key Hook + Crimping-29
Wire Cable +Snap Key Hook + Crimping-30
Wire Cable +Snap Key Hook + Crimping-31
Wire Cable +Snap Key Hook + Crimping-32
Wire Cable +Snap Key Hook + Crimping-33
Wire Cable +Snap Key Hook + Crimping-34
3.5mm Wood Screw Cross Head-151
3.5mm Wood Screw Cross Head-152
3.5mm Wood Screw Cross Head-153
3.5mm Wood Screw Cross Head-154
3.5mm Wood Screw Cross Head-155
3.5mm Wood Screw Cross Head-156
3.5mm Wood Screw Cross Head-157
3.5mm Wood Screw Cross Head-158
3.5mm Wood Screw Cross Head-159
3.5mm Wood Screw Cross Head-160
3.5mm Wood Screw Cross Head-161
3.5mm Wood Screw Cross Head-162
3.5mm Wood Screw Cross Head-163
3.5mm Wood Screw Cross Head-164
3.5mm Wood Screw Cross Head-165
3.5mm Wood Screw Cross Head-166
3.5mm Wood Screw Cross Head-167
3.5mm Wood Screw Cross Head-168
3.5mm Wood Screw Cross Head-169
3.5mm Wood Screw Cross Head-170
3.5mm Wood Screw Cross Head-171
3.5mm Wood Screw Cross Head-172
3.5mm Wood Screw Cross Head-173
3.5mm Wood Screw Cross Head-174
3.5mm Wood Screw Cross Head-175
3.5mm Wood Screw Cross Head-176
3.5mm Wood Screw Cross Head-177
3.5mm Wood Screw Cross Head-178
3.5mm Wood Screw Cross Head-179
3.5mm Wood Screw Cross Head-180
3.5mm Wood Screw Cross Head-181
3.5mm Wood Screw Cross Head-182
3.5mm Wood Screw Cross Head-183
3.5mm Wood Screw Cross Head-184
3.5mm Wood Screw Cross Head-185
3.5mm Wood Screw Cross Head-186
3.5mm Wood Screw Cross Head-187
3.5mm Wood Screw Cross Head-188
3.5mm Wood Screw Cross Head-189
3.5mm Wood Screw Cross Head-190
3.5mm Wood Screw Cross Head-191
3.5mm Wood Screw Cross Head-192
3.5mm Wood Screw Cross Head-193
3.5mm Wood Screw Cross Head-194
3.5mm Wood Screw Cross Head-195
3.5mm Wood Screw Cross Head-196
3.5mm Wood Screw Cross Head-197
3.5mm Wood Screw Cross Head-198
3.5mm Wood Screw Cross Head-199
3.5mm Wood Screw Cross Head-200
3.5mm Wood Screw Cross Head-201
3.5mm Wood Screw Cross Head-202
3.5mm Wood Screw Cross Head-203
3.5mm Wood Screw Cross Head-204
3.5mm Wood Screw Cross Head-205
3.5mm Wood Screw Cross Head-206
3.5mm Wood Screw Cross Head-207
3.5mm Wood Screw Cross Head-208
3.5mm Wood Screw Cross Head-209
3.5mm Wood Screw Cross Head-210
3.5mm Wood Screw Cross Head-211
3.5mm Wood Screw Cross Head-212
3.5mm Wood Screw Cross Head-213
3.5mm Wood Screw Cross Head-214
3.5mm Wood Screw Cross Head-215
3.5mm Wood Screw Cross Head-216
3.5mm Wood Screw Cross Head-217
3.5mm Wood Screw Cross Head-218
3.5mm Wood Screw Cross Head-219
3.5mm Wood Screw Cross Head-220
3.5mm Wood Screw Cross Head-221
3.5mm Wood Screw Cross Head-222
3.5mm Wood Screw Cross Head-223
3.5mm Wood Screw Cross Head-224
3.5mm Wood Screw Cross Head-225
3.5mm Wood Screw Cross Head-226
3.5mm Wood Screw Cross Head-227
3.5mm Wood Screw Cross Head-228
3.5mm Wood Screw Cross Head-229
3.5mm Wood Screw Cross Head-230
3.5mm Wood Screw Cross Head-231
3.5mm Wood Screw Cross Head-232
3.5mm Wood Screw Cross Head-233
3.5mm Wood Screw Cross Head-234
3.5mm Wood Screw Cross Head-235
3.5mm Wood Screw Cross Head-236
3.5mm Wood Screw Cross Head-237
3.5mm Wood Screw Cross Head-238
3.5mm Wood Screw Cross Head-239
3.5mm Wood Screw Cross Head-240
3.5mm Wood Screw Cross Head-241
3.5mm Wood Screw Cross Head-242
3.5mm Wood Screw Cross Head-243
3.5mm Wood Screw Cross Head-244
3.5mm Wood Screw Cross Head-245
3.5mm Wood Screw Cross Head-246
3.5mm Wood Screw Cross Head-247
3.5mm Wood Screw Cross Head-248
3.5mm Wood Screw Cross Head-249
3.5mm Wood Screw Cross Head-250
3.5mm Wood Screw Cross Head-251
3.5mm Wood Screw Cross Head-252
3.5mm Wood Screw Cross Head-253
3.5mm Wood Screw Cross Head-254
3.5mm Wood Screw Cross Head-255
3.5mm Wood Screw Cross Head-256
3.5mm Wood Screw Cross Head-257
3.5mm Wood Screw Cross Head-258
3.5mm Wood Screw Cross Head-259
3.5mm Wood Screw Cross Head-260
3.5mm Wood Screw Cross Head-261
3.5mm Wood Screw Cross Head-262
3.5mm Wood Screw Cross Head-263
3.5mm Wood Screw Cross Head-264
3.5mm Wood Screw Cross Head-265
3.5mm Wood Screw Cross Head-266
3.5mm Wood Screw Cross Head-267
3.5mm Wood Screw Cross Head-268
3.5mm Wood Screw Cross Head-269
3.5mm Wood Screw Cross Head-270
3.5mm Wood Screw Cross Head-271
3.5mm Wood Screw Cross Head-272
3.5mm Wood Screw Cross Head-273
3.5mm Wood Screw Cross Head-274
3.5mm Wood Screw Cross Head-275
3.5mm Wood Screw Cross Head-276
3.5mm Wood Screw Cross Head-277
3.5mm Wood Screw Cross Head-278
3.5mm Wood Screw Cross Head-279
3.5mm Wood Screw Cross Head-280
3.5mm Wood Screw Cross Head-281
3.5mm Wood Screw Cross Head-282
3.5mm Wood Screw Cross Head-283
3.5mm Wood Screw Cross Head-284
3.5mm Wood Screw Cross Head-285
3.5mm Wood Screw Cross Head-286
3.5mm Wood Screw Cross Head-287
3.5mm Wood Screw Cross Head-288
3.5mm Wood Screw Cross Head-289
3.5mm Wood Screw Cross Head-290
3.5mm Wood Screw Cross Head-291
3.5mm Wood Screw Cross Head-292
3.5mm Wood Screw Cross Head-293
3.5mm Wood Screw Cross Head-294
3.5mm Wood Screw Cross Head-295
3.5mm Wood Screw Cross Head-296
3.5mm Wood Screw Cross Head-297
3.5mm Wood Screw Cross Head-298
3.5mm Wood Screw Cross Head-299
3.5mm Wood Screw Cross Head-300
3.5mm Wood Screw Cross Head-301
3.5mm Wood Screw Cross Head-302
3.5mm Wood Screw Cross Head-303
3.5mm Wood Screw Cross Head-304
3.5mm Wood Screw Cross Head-305
3.5mm Wood Screw Cross Head-306
3.5mm Wood Screw Cross Head-307
3.5mm Wood Screw Cross Head-308
3.5mm Wood Screw Cross Head-309
3.5mm Wood Screw Cross Head-310
3.5mm Wood Screw Cross Head-311
3.5mm Wood Screw Cross Head-312
3.5mm Wood Screw Cross Head-313
3.5mm Wood Screw Cross Head-314
3.5mm Wood Screw Cross Head-315
3.5mm Wood Screw Cross Head-316
3.5mm Wood Screw Cross Head-317
3.5mm Wood Screw Cross Head-318
3.5mm Wood Screw Cross Head-319
3.5mm Wood Screw Cross Head-320
3.5mm Wood Screw Cross Head-321
3.5mm Wood Screw Cross Head-322
3.5mm Wood Screw Cross Head-323
3.5mm Wood Screw Cross Head-324
3.5mm Wood Screw Cross Head-325
3.5mm Wood Screw Cross Head-326
3.5mm Wood Screw Cross Head-327
3.5mm Wood Screw Cross Head-328
3.5mm Wood Screw Cross Head-329
3.5mm Wood Screw Cross Head-330
3.5mm Wood Screw Cross Head-331
3.5mm Wood Screw Cross Head-332
3.5mm Wood Screw Cross Head-333
3.5mm Wood Screw Cross Head-334
3.5mm Wood Screw Cross Head-335
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-24
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-25
3.5mm Wood Screw Cross Head-336
3.5mm Wood Screw Cross Head-337
3.5mm Wood Screw Cross Head-338
3.5mm Wood Screw Cross Head-339
3.5mm Wood Screw Cross Head-340
3.5mm Wood Screw Cross Head-341
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-26
3.5mm Wood Screw Cross Head-342
3.5mm Wood Screw Cross Head-343
3.5mm Wood Screw Cross Head-344
3.5mm Wood Screw Cross Head-345
3.5mm Wood Screw Cross Head-346
3.5mm Wood Screw Cross Head-347
3.5mm Wood Screw Cross Head-348
3.5mm Wood Screw Cross Head-349
3.5mm Wood Screw Cross Head-350
3.5mm Wood Screw Cross Head-351
3.5mm Wood Screw Cross Head-352
3.5mm Wood Screw Cross Head-353
3.5mm Wood Screw Cross Head-354
3.5mm Wood Screw Cross Head-355
3.5mm Wood Screw Cross Head-356
3.5mm Wood Screw Cross Head-357
3.5mm Wood Screw Cross Head-358
3.5mm Wood Screw Cross Head-359
3.5mm Wood Screw Cross Head-360
3.5mm Wood Screw Cross Head-361
3.5mm Wood Screw Cross Head-362
3.5mm Wood Screw Cross Head-363
3.5mm Wood Screw Cross Head-364
3.5mm Wood Screw Cross Head-365
3.5mm Wood Screw Cross Head-366
3.5mm Wood Screw Cross Head-367
3.5mm Wood Screw Cross Head-368
3.5mm Wood Screw Cross Head-369
3.5mm Wood Screw Cross Head-370
3.5mm Wood Screw Cross Head-371
3.5mm Wood Screw Cross Head-372
3.5mm Wood Screw Cross Head-373
3.5mm Wood Screw Cross Head-374
3.5mm Wood Screw Cross Head-375
3.5mm Wood Screw Cross Head-376
3.5mm Wood Screw Cross Head-377
3.5mm Wood Screw Cross Head-378
3.5mm Wood Screw Cross Head-379
3.5mm Wood Screw Cross Head-380
3.5mm Wood Screw Cross Head-381
3.5mm Wood Screw Cross Head-382
3.5mm Wood Screw Cross Head-383
3.5mm Wood Screw Cross Head-384
3.5mm Wood Screw Cross Head-385
3.5mm Wood Screw Cross Head-386
3.5mm Wood Screw Cross Head-387
3.5mm Wood Screw Cross Head-388
3.5mm Wood Screw Cross Head-389
3.5mm Wood Screw Cross Head-390
3.5mm Wood Screw Cross Head-391
3.5mm Wood Screw Cross Head-392
3.5mm Wood Screw Cross Head-393
3.5mm Wood Screw Cross Head-394
3.5mm Wood Screw Cross Head-395
3.5mm Wood Screw Cross Head-396
3.5mm Wood Screw Cross Head-397
3.5mm Wood Screw Cross Head-398
3.5mm Wood Screw Cross Head-399
3.5mm Wood Screw Cross Head-400
3.5mm Wood Screw Cross Head-401
3.5mm Wood Screw Cross Head-402
3.5mm Wood Screw Cross Head-403
3.5mm Wood Screw Cross Head-404
3.5mm Wood Screw Cross Head-405
3.5mm Wood Screw Cross Head-406
3.5mm Wood Screw Cross Head-407
3.5mm Wood Screw Cross Head-408
3.5mm Wood Screw Cross Head-409
3.5mm Wood Screw Cross Head-410
3.5mm Wood Screw Cross Head-411
3.5mm Wood Screw Cross Head-412
3.5mm Wood Screw Cross Head-413
3.5mm Wood Screw Cross Head-414
3.5mm Wood Screw Cross Head-415
3.5mm Wood Screw Cross Head-416
3.5mm Wood Screw Cross Head-417
3.5mm Wood Screw Cross Head-418
3.5mm Wood Screw Cross Head-419
3.5mm Wood Screw Cross Head-420
3.5mm Wood Screw Cross Head-421
3.5mm Wood Screw Cross Head-422
3.5mm Wood Screw Cross Head-423
3.5mm Wood Screw Cross Head-424
3.5mm Wood Screw Cross Head-425
3.5mm Wood Screw Cross Head-426
3.5mm Wood Screw Cross Head-427
3.5mm Wood Screw Cross Head-428
3.5mm Wood Screw Cross Head-429
3.5mm Wood Screw Cross Head-430
3.5mm Wood Screw Cross Head-431
3.5mm Wood Screw Cross Head-432
3.5mm Wood Screw Cross Head-433
3.5mm Wood Screw Cross Head-434
3.5mm Wood Screw Cross Head-435
3.5mm Wood Screw Cross Head-436
3.5mm Wood Screw Cross Head-437
3.5mm Wood Screw Cross Head-438
3.5mm Wood Screw Cross Head-439
3.5mm Wood Screw Cross Head-440
3.5mm Wood Screw Cross Head-441
3.5mm Wood Screw Cross Head-442
3.5mm Wood Screw Cross Head-443
3.5mm Wood Screw Cross Head-444
3.5mm Wood Screw Cross Head-445
3.5mm Wood Screw Cross Head-446
3.5mm Wood Screw Cross Head-447
3.5mm Wood Screw Cross Head-448
3.5mm Wood Screw Cross Head-449
3.5mm Wood Screw Cross Head-450
3.5mm Wood Screw Cross Head-451
3.5mm Wood Screw Cross Head-452
3.5mm Wood Screw Cross Head-453
3.5mm Wood Screw Cross Head-454
3.5mm Wood Screw Cross Head-455
3.5mm Wood Screw Cross Head-456
3.5mm Wood Screw Cross Head-457
3.5mm Wood Screw Cross Head-458
3.5mm Wood Screw Cross Head-459
3.5mm Wood Screw Cross Head-460
3.5mm Wood Screw Cross Head-461
3.5mm Wood Screw Cross Head-462
EGRC-PARK-017 SIDE CHANNEL-2 | SOLIDWORKS Custom Properties - DESCRIPTION: SIDE CHANNEL; PARTNUMBER: EGRC-PARK-017; REVISION: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE + ASSEMBLY; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
3.5mm Wood Screw Cross Head-463
3.5mm Wood Screw Cross Head-464
3.5mm Wood Screw Cross Head-465
3.5mm Wood Screw Cross Head-466
3.5mm Wood Screw Cross Head-467
3.5mm Wood Screw Cross Head-468
3.5mm Wood Screw Cross Head-469
3.5mm Wood Screw Cross Head-470
3.5mm Wood Screw Cross Head-471
3.5mm Wood Screw Cross Head-472
3.5mm Wood Screw Cross Head-473
3.5mm Wood Screw Cross Head-474
3.5mm Wood Screw Cross Head-475
3.5mm Wood Screw Cross Head-476
3.5mm Wood Screw Cross Head-477
3.5mm Wood Screw Cross Head-478
3.5mm Wood Screw Cross Head-479
3.5mm Wood Screw Cross Head-480
3.5mm Wood Screw Cross Head-481
3.5mm Wood Screw Cross Head-482
3.5mm Wood Screw Cross Head-483
3.5mm Wood Screw Cross Head-484
3.5mm Wood Screw Cross Head-485
3.5mm Wood Screw Cross Head-486
3.5mm Wood Screw Cross Head-487
3.5mm Wood Screw Cross Head-488
3.5mm Wood Screw Cross Head-489
3.5mm Wood Screw Cross Head-490
3.5mm Wood Screw Cross Head-491
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-27
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-28
3.5mm Wood Screw Cross Head-492
3.5mm Wood Screw Cross Head-493
3.5mm Wood Screw Cross Head-494
3.5mm Wood Screw Cross Head-495
3.5mm Wood Screw Cross Head-496
3.5mm Wood Screw Cross Head-497
3.5mm Wood Screw Cross Head-498
3.5mm Wood Screw Cross Head-499
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-29
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-30
3.5mm Wood Screw Cross Head-500
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-31
3.5mm Wood Screw Cross Head-501
3.5mm Wood Screw Cross Head-502
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-32
3.5mm Wood Screw Cross Head-503
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-33
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-34
3.5mm Wood Screw Cross Head-504
3.5mm Wood Screw Cross Head-505
3.5mm Wood Screw Cross Head-506
3.5mm Wood Screw Cross Head-507
3.5mm Wood Screw Cross Head-508
3.5mm Wood Screw Cross Head-509
3.5mm Wood Screw Cross Head-510
3.5mm Wood Screw Cross Head-511
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-35
EGRC-PARK-008 RAIL ASSEMBLY.SLDPRT
9 x EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-32
9 x EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-33
9 x EGRC-PARK-015 CENTRAL CHANNEL | SOLIDWORKS Custom Properties - Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2; Description: CENTRAL CHANNEL; PartNo: EGRC-PARK-015; Revision: A
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-144
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-145
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-146
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-147
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-148
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-149
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-150
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-151
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-152
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-16
EGRC-PARK-017 SIDE CHANNEL-3 | SOLIDWORKS Custom Properties - DESCRIPTION: SIDE CHANNEL; PARTNUMBER: EGRC-PARK-017; REVISION: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE + ASSEMBLY; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496-3
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-6
EGRC-PARK-005 CORNER
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-7
3.5mm Wood Screw Cross Head-512
3.5mm Wood Screw Cross Head-513
3.5mm Wood Screw Cross Head-514
3.5mm Wood Screw Cross Head-515
3.5mm Wood Screw Cross Head-516
3.5mm Wood Screw Cross Head-517
3.5mm Wood Screw Cross Head-518
3.5mm Wood Screw Cross Head-519
3.5mm Wood Screw Cross Head-520
3.5mm Wood Screw Cross Head-521
3.5mm Wood Screw Cross Head-522
3.5mm Wood Screw Cross Head-523
3.5mm Wood Screw Cross Head-524
3.5mm Wood Screw Cross Head-525
3.5mm Wood Screw Cross Head-526
3.5mm Wood Screw Cross Head-527
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-8
3.5mm Wood Screw Cross Head-528
Wire Cable +Snap Key Hook + Crimping-35
3.5mm Wood Screw Cross Head-529
CROSS TEE RAIL SECTION-16
CROSS TEE RAIL SECTION-17
CROSS TEE RAIL SECTION-18
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-17
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-18
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-19
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-20
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-21
EGRC-PARK-008 RAIL ASSEMBLY.SLDPRT-1
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-22
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-23
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-24
EGRC-PARK-008 RAIL ASSEMBLY.SLDPRT-2
EGRC-PARK-008 RAIL ASSEMBLY.SLDPRT-3
EGRC-PARK-005 CORNER-1
EGRC-PARK-008 RAIL ASSEMBLY.SLDPRT-4
EGRC-PARK-008 RAIL ASSEMBLY.SLDPRT-5
EGRC-PARK-005 CORNER-2
EGRC-PARK-005 CORNER-3
EGRC-PARK-008 RAIL ASSEMBLY.SLDPRT-6
EGRC-PARK-008 RAIL ASSEMBLY.SLDPRT-7
EGRC-PARK-008 RAIL ASSEMBLY.SLDPRT-8
3.5mm Wood Screw Cross Head-530
3.5mm Wood Screw Cross Head-531
3.5mm Wood Screw Cross Head-532
3.5mm Wood Screw Cross Head-533
3.5mm Wood Screw Cross Head-534
3.5mm Wood Screw Cross Head-535
3.5mm Wood Screw Cross Head-536
3.5mm Wood Screw Cross Head-537
3.5mm Wood Screw Cross Head-538
3.5mm Wood Screw Cross Head-539
3.5mm Wood Screw Cross Head-540
3.5mm Wood Screw Cross Head-541
3.5mm Wood Screw Cross Head-542
3.5mm Wood Screw Cross Head-543
3.5mm Wood Screw Cross Head-544
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-9
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-10
3.5mm Wood Screw Cross Head-545
3.5mm Wood Screw Cross Head-546
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-11
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-12
3.5mm Wood Screw Cross Head-547
3.5mm Wood Screw Cross Head-548
3.5mm Wood Screw Cross Head-549
3.5mm Wood Screw Cross Head-550
3.5mm Wood Screw Cross Head-551
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-13
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-14
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-15
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-16
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-17
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-18
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-19
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-20
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-21
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-22
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-23
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-24
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-25
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-26
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-27
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-28
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-29
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-30
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-31
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-32
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-33
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-34
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-35
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-36
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-37
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-38
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-39
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-40
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-41
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-42
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-43
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-44
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-45
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-46
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-47
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-48
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-49
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-50
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-51
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-52
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-53
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-54
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-55
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-56
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-57
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-58
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-59
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-60
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-61
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-62
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-63
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-64
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-65
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-66
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-67
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-68
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-69
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-70
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-71
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-72
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-73
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-74
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-75
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-76
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-77
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-78
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-79
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-80
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-81
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-82
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-83
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-84
CROSS TEE RAIL SECTION-19
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-85
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-86
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-87
CROSS TEE RAIL SECTION-20
CROSS TEE RAIL SECTION-21
CROSS TEE RAIL SECTION-22
CROSS TEE RAIL SECTION-23
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-88
CROSS TEE RAIL SECTION-24
CROSS TEE RAIL SECTION-25
CROSS TEE RAIL SECTION-26
CROSS TEE RAIL SECTION-27
CROSS TEE RAIL SECTION-28
CROSS TEE RAIL SECTION-29
CROSS TEE RAIL SECTION-30
CROSS TEE RAIL SECTION-31
CROSS TEE RAIL SECTION-32
CROSS TEE RAIL SECTION-33
CROSS TEE RAIL SECTION-34
CROSS TEE RAIL SECTION-35
CROSS TEE RAIL SECTION-36
CROSS TEE RAIL SECTION-37
CROSS TEE RAIL SECTION-38
CROSS TEE RAIL SECTION-39
CROSS TEE RAIL SECTION-40
CROSS TEE RAIL SECTION-41
CROSS TEE RAIL SECTION-42
CROSS TEE RAIL SECTION-43
CROSS TEE RAIL SECTION-44
CROSS TEE RAIL SECTION-45
CROSS TEE RAIL SECTION-46
CROSS TEE RAIL SECTION-47
CROSS TEE RAIL SECTION-48
CROSS TEE RAIL SECTION-49
CROSS TEE RAIL SECTION-50
CROSS TEE RAIL SECTION-51
CROSS TEE RAIL SECTION-52
CROSS TEE RAIL SECTION-53
CROSS TEE RAIL SECTION-54
CROSS TEE RAIL SECTION-55
CROSS TEE RAIL SECTION-56
CROSS TEE RAIL SECTION-57
CROSS TEE RAIL SECTION-58
CROSS TEE RAIL SECTION-59
CROSS TEE RAIL SECTION-60
CROSS TEE RAIL SECTION-61
CROSS TEE RAIL SECTION-62
CROSS TEE RAIL SECTION-63
CROSS TEE RAIL SECTION-64
CROSS TEE RAIL SECTION-65
CROSS TEE RAIL SECTION-66
CROSS TEE RAIL SECTION-67
CROSS TEE RAIL SECTION-68
CROSS TEE RAIL SECTION-69
CROSS TEE RAIL SECTION-70
CROSS TEE RAIL SECTION-71
CROSS TEE RAIL SECTION-72
CROSS TEE RAIL SECTION-73
CROSS TEE RAIL SECTION-74
CROSS TEE RAIL SECTION-75
CROSS TEE RAIL SECTION-76
CROSS TEE RAIL SECTION-77
CROSS TEE RAIL SECTION-78
CROSS TEE RAIL SECTION-79
CROSS TEE RAIL SECTION-80
CROSS TEE RAIL SECTION-81
CROSS TEE RAIL SECTION-82
CROSS TEE RAIL SECTION-83
CROSS TEE RAIL SECTION-84
CROSS TEE RAIL SECTION-85
CROSS TEE RAIL SECTION-86
CROSS TEE RAIL SECTION-87
CROSS TEE RAIL SECTION-88
CROSS TEE RAIL SECTION-89
CROSS TEE RAIL SECTION-90
CROSS TEE RAIL SECTION-91
CROSS TEE RAIL SECTION-92
CROSS TEE RAIL SECTION-93
CROSS TEE RAIL SECTION-94
CROSS TEE RAIL SECTION-95
CROSS TEE RAIL SECTION-96
CROSS TEE RAIL SECTION-97
CROSS TEE RAIL SECTION-98
CROSS TEE RAIL SECTION-99
CROSS TEE RAIL SECTION-100
CROSS TEE RAIL SECTION-101
CROSS TEE RAIL SECTION-102
