Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-012 END CHANNEL.IFC
Time: 2024-12-17T11:19:06+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 6.0583040000000317; Volume Measure: 0.0060583040000000; Area Measure: 1.3742144414312301

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 6.0583040000000317; Volume Measure: 0.0060583040000000; Area Measure: 1.3742144414312301

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 6.0583040000000317; Volume Measure: 0.0060583040000000; Area Measure: 1.3742144414312301

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-PARK-012 END CHANNEL | PSet_Mass_Property - Mass Measure: 6.0583040000000317; Volume Measure: 0.0060583040000000; Area Measure: 1.3742144414312301
EGRC-PARK-012 END CHANNEL | SOLIDWORKS Custom Properties - DESCRIPTION: END CHANNEL; PARTNUMBER: EGRC-PARK-012; REVISION: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE + ASSEMBLY; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
