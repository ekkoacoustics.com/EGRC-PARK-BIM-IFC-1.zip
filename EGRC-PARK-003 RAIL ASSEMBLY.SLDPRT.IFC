Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-003 RAIL ASSEMBLY.SLDPRT.IFC
Time: 2024-12-17T14:42:38+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 7.8483839999999319; Volume Measure: 0.0078483839999999; Area Measure: 1.7426487617492705

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 7.8483839999999319; Volume Measure: 0.0078483839999999; Area Measure: 1.7426487617492705

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 7.8483839999999319; Volume Measure: 0.0078483839999999; Area Measure: 1.7426487617492705

# IfcBuildingElementProxy (6)
In: default BuildingStorey
Name
EGRC-PARK-003 RAIL ASSEMBLY.SLDPRT | PSet_Mass_Property - Mass Measure: 7.8483839999999319; Volume Measure: 0.0078483839999999; Area Measure: 1.7426487617492705
EGRC-PARK-013 CENTRAL CHANNEL
EGRC-PARK-008 CROSS CHANNEL PLATE
EGRC-PARK-008 CROSS CHANNEL PLATE-1
EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE
EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-1
