Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496.IFC
Time: 2024-12-17T11:31:54+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 0.0041190551921693; Volume Measure: 0.0000041190551922; Area Measure: 0.0049733187012891

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 0.0041190551921693; Volume Measure: 0.0000041190551922; Area Measure: 0.0049733187012891

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 0.0041190551921693; Volume Measure: 0.0000041190551922; Area Measure: 0.0049733187012891

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496 | PSet_Mass_Property - Mass Measure: 0.0041190551921693; Volume Measure: 0.0000041190551922; Area Measure: 0.0049733187012891
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496
