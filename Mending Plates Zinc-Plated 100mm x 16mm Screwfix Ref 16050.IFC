Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050.IFC
Time: 2024-12-17T11:07:50+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 0.0028475551921693; Volume Measure: 0.0000028475551922; Area Measure: 0.0035578187012891

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 0.0028475551921693; Volume Measure: 0.0000028475551922; Area Measure: 0.0035578187012891

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 0.0028475551921693; Volume Measure: 0.0000028475551922; Area Measure: 0.0035578187012891

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050 | PSet_Mass_Property - Mass Measure: 0.0028475551921693; Volume Measure: 0.0000028475551922; Area Measure: 0.0035578187012891
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050
