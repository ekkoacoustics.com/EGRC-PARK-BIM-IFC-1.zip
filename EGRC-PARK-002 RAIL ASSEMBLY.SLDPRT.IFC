Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-002 RAIL ASSEMBLY.SLDPRT.IFC
Time: 2024-12-17T14:45:20+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 10.4686079999999286; Volume Measure: 0.0104686079999999; Area Measure: 2.3230021123456135

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 10.4686079999999286; Volume Measure: 0.0104686079999999; Area Measure: 2.3230021123456135

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 10.4686079999999286; Volume Measure: 0.0104686079999999; Area Measure: 2.3230021123456135

# IfcBuildingElementProxy (7)
In: default BuildingStorey
Name
EGRC-PARK-002 RAIL ASSEMBLY.SLDPRT | PSet_Mass_Property - Mass Measure: 10.4686079999999286; Volume Measure: 0.0104686079999999; Area Measure: 2.3230021123456135
EGRC-PARK-008 CROSS CHANNEL PLATE
EGRC-PARK-008 CROSS CHANNEL PLATE-1
EGRC-PARK-008 CROSS CHANNEL PLATE-2
EGRC-PARK-003 CENTRAL CHANNEL
EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE
EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-1
