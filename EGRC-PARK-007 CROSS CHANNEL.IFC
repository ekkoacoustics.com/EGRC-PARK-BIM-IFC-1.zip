Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-007 CROSS CHANNEL.IFC
Time: 2024-12-17T11:23:55+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 4.3987200000000719; Volume Measure: 0.0043987200000001; Area Measure: 0.8472874111529348

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 4.3987200000000719; Volume Measure: 0.0043987200000001; Area Measure: 0.8472874111529348

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 4.3987200000000719; Volume Measure: 0.0043987200000001; Area Measure: 0.8472874111529348

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-PARK-007 CROSS CHANNEL | PSet_Mass_Property - Mass Measure: 4.3987200000000719; Volume Measure: 0.0043987200000001; Area Measure: 0.8472874111529348
EGRC-PARK-007 CROSS CHANNEL
