Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\3.5mm Wood Screw Cross Head.IFC
Time: 2024-12-17T11:32:50+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 0.0002311039690748; Volume Measure: 0.0000002311039691; Area Measure: 0.0004940144157711

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 0.0002311039690748; Volume Measure: 0.0000002311039691; Area Measure: 0.0004940144157711

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 0.0002311039690748; Volume Measure: 0.0000002311039691; Area Measure: 0.0004940144157711

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
3.5mm Wood Screw Cross Head | PSet_Mass_Property - Mass Measure: 0.0002311039690748; Volume Measure: 0.0000002311039691; Area Measure: 0.0004940144157711
3.5mm Wood Screw Cross Head | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
