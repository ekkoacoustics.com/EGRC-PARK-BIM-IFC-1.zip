Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-015 CENTRAL CHANNEL.IFC
Time: 2024-12-17T11:15:41+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 20.7803519999999651; Volume Measure: 0.0207803520000000; Area Measure: 4.7087542159237001

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 20.7803519999999651; Volume Measure: 0.0207803520000000; Area Measure: 4.7087542159237001

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 20.7803519999999651; Volume Measure: 0.0207803520000000; Area Measure: 4.7087542159237001

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-PARK-015 CENTRAL CHANNEL | PSet_Mass_Property - Mass Measure: 20.7803519999999651; Volume Measure: 0.0207803520000000; Area Measure: 4.7087542159237001
EGRC-PARK-015 CENTRAL CHANNEL | SOLIDWORKS Custom Properties - Description: CENTRAL CHANNEL; PartNo: EGRC-PARK-015; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
