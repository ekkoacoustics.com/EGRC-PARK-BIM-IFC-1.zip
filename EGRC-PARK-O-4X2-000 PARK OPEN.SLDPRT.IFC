Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-O-4X2-000 PARK OPEN.SLDPRT.IFC
Time: 2024-12-17T16:30:03+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 59.9847255274815865; Volume Measure: 0.0599847255274818; Area Measure: 16.7782945989611640

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 59.9847255274815865; Volume Measure: 0.0599847255274818; Area Measure: 16.7782945989611640

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 59.9847255274815865; Volume Measure: 0.0599847255274818; Area Measure: 16.7782945989611640

# IfcBuildingElementProxy (185)
In: default BuildingStorey
Name | UNIT_OF_MEASURE | sets with these values
EGRC-PARK-O-4X2-000 PARK OPEN.SLDPRT | PSet_Mass_Property - Mass Measure: 59.9847255274815865; Volume Measure: 0.0599847255274818; Area Measure: 16.7782945989611640
Wire Cable +Snap Key Hook + Crimping
Wire Cable +Snap Key Hook + Crimping-1
Wire Cable +Snap Key Hook + Crimping-2
Wire Cable +Snap Key Hook + Crimping-3
Wire Cable +Snap Key Hook + Crimping-4
Wire Cable +Snap Key Hook + Crimping-5
Wire Cable +Snap Key Hook + Crimping-6
Wire Cable +Snap Key Hook + Crimping-7
Wire Cable +Snap Key Hook + Crimping-8
Wire Cable +Snap Key Hook + Crimping-9
CROSS TEE RAIL SECTION
Wire Cable +Snap Key Hook + Crimping-10
Wire Cable +Snap Key Hook + Crimping-11
Wire Cable +Snap Key Hook + Crimping-12
Wire Cable +Snap Key Hook + Crimping-13
3.5mm Wood Screw Cross Head | - none - | 2
3.5mm Wood Screw Cross Head-1 | - none - | 2
3.5mm Wood Screw Cross Head-2 | - none - | 2
3.5mm Wood Screw Cross Head-3 | - none - | 2
3.5mm Wood Screw Cross Head-4 | - none - | 2
3.5mm Wood Screw Cross Head-5 | - none - | 2
3.5mm Wood Screw Cross Head-6 | - none - | 2
3.5mm Wood Screw Cross Head-7 | - none - | 2
3.5mm Wood Screw Cross Head-8 | - none - | 2
3.5mm Wood Screw Cross Head-9 | - none - | 2
3.5mm Wood Screw Cross Head-10 | - none - | 2
3.5mm Wood Screw Cross Head-11 | - none - | 2
3.5mm Wood Screw Cross Head-12 | - none - | 2
3.5mm Wood Screw Cross Head-13 | - none - | 2
Wire Cable +Snap Key Hook + Crimping-14
3.5mm Wood Screw Cross Head-14 | - none - | 2
3.5mm Wood Screw Cross Head-15 | - none - | 2
3.5mm Wood Screw Cross Head-16 | - none - | 2
3.5mm Wood Screw Cross Head-17 | - none - | 2
3.5mm Wood Screw Cross Head-18 | - none - | 2
3.5mm Wood Screw Cross Head-19 | - none - | 2
3.5mm Wood Screw Cross Head-20 | - none - | 2
3.5mm Wood Screw Cross Head-21 | - none - | 2
3.5mm Wood Screw Cross Head-22 | - none - | 2
3.5mm Wood Screw Cross Head-23 | - none - | 2
3.5mm Wood Screw Cross Head-24 | - none - | 2
3.5mm Wood Screw Cross Head-25 | - none - | 2
3.5mm Wood Screw Cross Head-26 | - none - | 2
3.5mm Wood Screw Cross Head-27 | - none - | 2
3.5mm Wood Screw Cross Head-28 | - none - | 2
3.5mm Wood Screw Cross Head-29 | - none - | 2
3.5mm Wood Screw Cross Head-30 | - none - | 2
3.5mm Wood Screw Cross Head-31 | - none - | 2
3.5mm Wood Screw Cross Head-32 | - none - | 2
3.5mm Wood Screw Cross Head-33 | - none - | 2
3.5mm Wood Screw Cross Head-34 | - none - | 2
3.5mm Wood Screw Cross Head-35 | - none - | 2
3.5mm Wood Screw Cross Head-36 | - none - | 2
3.5mm Wood Screw Cross Head-37 | - none - | 2
3.5mm Wood Screw Cross Head-38 | - none - | 2
3.5mm Wood Screw Cross Head-39 | - none - | 2
3.5mm Wood Screw Cross Head-40 | - none - | 2
3.5mm Wood Screw Cross Head-41 | - none - | 2
3.5mm Wood Screw Cross Head-42 | - none - | 2
3.5mm Wood Screw Cross Head-43 | - none - | 2
3.5mm Wood Screw Cross Head-44 | - none - | 2
3.5mm Wood Screw Cross Head-45 | - none - | 2
3.5mm Wood Screw Cross Head-46 | - none - | 2
3.5mm Wood Screw Cross Head-47 | - none - | 2
3.5mm Wood Screw Cross Head-48 | - none - | 2
3.5mm Wood Screw Cross Head-49 | - none - | 2
3.5mm Wood Screw Cross Head-50 | - none - | 2
3.5mm Wood Screw Cross Head-51 | - none - | 2
3.5mm Wood Screw Cross Head-52 | - none - | 2
3.5mm Wood Screw Cross Head-53 | - none - | 2
3.5mm Wood Screw Cross Head-54 | - none - | 2
3.5mm Wood Screw Cross Head-55 | - none - | 2
3.5mm Wood Screw Cross Head-56 | - none - | 2
3.5mm Wood Screw Cross Head-57 | - none - | 2
3.5mm Wood Screw Cross Head-58 | - none - | 2
3.5mm Wood Screw Cross Head-59 | - none - | 2
3.5mm Wood Screw Cross Head-60 | - none - | 2
3.5mm Wood Screw Cross Head-61 | - none - | 2
3.5mm Wood Screw Cross Head-62 | - none - | 2
3.5mm Wood Screw Cross Head-63 | - none - | 2
3.5mm Wood Screw Cross Head-64 | - none - | 2
3.5mm Wood Screw Cross Head-65 | - none - | 2
3.5mm Wood Screw Cross Head-66 | - none - | 2
3.5mm Wood Screw Cross Head-67 | - none - | 2
3.5mm Wood Screw Cross Head-68 | - none - | 2
3.5mm Wood Screw Cross Head-69 | - none - | 2
3.5mm Wood Screw Cross Head-70 | - none - | 2
3.5mm Wood Screw Cross Head-71 | - none - | 2
3.5mm Wood Screw Cross Head-72 | - none - | 2
3.5mm Wood Screw Cross Head-73 | - none - | 2
3.5mm Wood Screw Cross Head-74 | - none - | 2
3.5mm Wood Screw Cross Head-75 | - none - | 2
3.5mm Wood Screw Cross Head-76 | - none - | 2
3.5mm Wood Screw Cross Head-77 | - none - | 2
3.5mm Wood Screw Cross Head-78 | - none - | 2
3.5mm Wood Screw Cross Head-79 | - none - | 2
3.5mm Wood Screw Cross Head-80 | - none - | 2
3.5mm Wood Screw Cross Head-81 | - none - | 2
3.5mm Wood Screw Cross Head-82 | - none - | 2
EGRC-PARK-002 SIDE CHANNEL |  | 2 | SOLIDWORKS Custom Properties - DESCRIPTION: SIDE CHANNEL; PARTNUMBER: EGRC-PARK-002; REVISION: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE + ASSEMBLY; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST
EGRC-PARK-001 CROSS RAIL ASSEMBLY.SLDPRT
3 x EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE
3 x EGRC-PARK-006 CROSS CHANNEL
3 x EGRC-PARK-006 CROSS CHANNEL-1
3 x EGRC-PARK-008 CROSS CHANNEL PLATE
3 x EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-1
EGRC-PARK-001 END CHANNEL |  | 2 | SOLIDWORKS Custom Properties - DESCRIPTION: END CHANNEL; PARTNUMBER: EGRC-PARK-001; REVISION: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE + ASSEMBLY; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST
EGRC-PARK-001 CROSS RAIL ASSEMBLY.SLDPRT-1
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534
EGRC-PARK-005 CORNER
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-1
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-1
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-2
EGRC-PARK-005 CORNER-1
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-3
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-2
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496-1
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-4
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-3
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-5
CROSS TEE RAIL SECTION-1
CROSS TEE RAIL SECTION-2
CROSS TEE RAIL SECTION-3
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-4
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-6
CROSS TEE RAIL SECTION-4
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-5
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-6
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-7
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-7
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-8
EGRC-PARK-005 CORNER-2
EGRC-PARK-002 RAIL ASSEMBLY.SLDPRT
EGRC-PARK-008 CROSS CHANNEL PLATE-2
EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-4
EGRC-PARK-008 CROSS CHANNEL PLATE-3
EGRC-PARK-003 CENTRAL CHANNEL
EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-5
EGRC-PARK-008 CROSS CHANNEL PLATE-4
EGRC-PARK-001 END CHANNEL-1 |  | 2 | SOLIDWORKS Custom Properties - DESCRIPTION: END CHANNEL; PARTNUMBER: EGRC-PARK-001; REVISION: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE + ASSEMBLY; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST
EGRC-PARK-001 CROSS RAIL ASSEMBLY.SLDPRT-2
EGRC-PARK-002 SIDE CHANNEL-1 |  | 2 | SOLIDWORKS Custom Properties - DESCRIPTION: SIDE CHANNEL; PARTNUMBER: EGRC-PARK-002; REVISION: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE + ASSEMBLY; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST
EGRC-PARK-005 CORNER-3
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496-2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-8
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-9
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496-3
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-10
3.5mm Wood Screw Cross Head-83 | - none - | 2
3.5mm Wood Screw Cross Head-84 | - none - | 2
3.5mm Wood Screw Cross Head-85 | - none - | 2
CROSS TEE RAIL SECTION-5
3.5mm Wood Screw Cross Head-86 | - none - | 2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-11
3.5mm Wood Screw Cross Head-87 | - none - | 2
CROSS TEE RAIL SECTION-6
CROSS TEE RAIL SECTION-7
CROSS TEE RAIL SECTION-8
CROSS TEE RAIL SECTION-9
CROSS TEE RAIL SECTION-10
3.5mm Wood Screw Cross Head-88 | - none - | 2
3.5mm Wood Screw Cross Head-89 | - none - | 2
3.5mm Wood Screw Cross Head-90 | - none - | 2
3.5mm Wood Screw Cross Head-91 | - none - | 2
3.5mm Wood Screw Cross Head-92 | - none - | 2
3.5mm Wood Screw Cross Head-93 | - none - | 2
3.5mm Wood Screw Cross Head-94 | - none - | 2
3.5mm Wood Screw Cross Head-95 | - none - | 2
3.5mm Wood Screw Cross Head-96 | - none - | 2
3.5mm Wood Screw Cross Head-97 | - none - | 2
3.5mm Wood Screw Cross Head-98 | - none - | 2
3.5mm Wood Screw Cross Head-99 | - none - | 2
