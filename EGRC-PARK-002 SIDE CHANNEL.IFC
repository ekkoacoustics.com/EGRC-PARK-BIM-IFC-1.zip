Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-002 SIDE CHANNEL.IFC
Time: 2024-12-17T11:27:45+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 8.8147200000000918; Volume Measure: 0.0088147200000001; Area Measure: 1.9571477920275799

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 8.8147200000000918; Volume Measure: 0.0088147200000001; Area Measure: 1.9571477920275799

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 8.8147200000000918; Volume Measure: 0.0088147200000001; Area Measure: 1.9571477920275799

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-PARK-002 SIDE CHANNEL | PSet_Mass_Property - Mass Measure: 8.8147200000000918; Volume Measure: 0.0088147200000001; Area Measure: 1.9571477920275799
EGRC-PARK-002 SIDE CHANNEL | SOLIDWORKS Custom Properties - DESCRIPTION: SIDE CHANNEL; PARTNUMBER: EGRC-PARK-002; REVISION: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE + ASSEMBLY; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
