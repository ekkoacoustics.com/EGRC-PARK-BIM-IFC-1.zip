Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-014 CENTRAL CHANNEL.IFC
Time: 2024-12-17T11:16:48+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 10.3605119999999999; Volume Measure: 0.0103605120000000; Area Measure: 2.3467474629419698

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 10.3605119999999999; Volume Measure: 0.0103605120000000; Area Measure: 2.3467474629419698

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 10.3605119999999999; Volume Measure: 0.0103605120000000; Area Measure: 2.3467474629419698

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-PARK-014 CENTRAL CHANNEL | PSet_Mass_Property - Mass Measure: 10.3605119999999999; Volume Measure: 0.0103605120000000; Area Measure: 2.3467474629419698
EGRC-PARK-014 CENTRAL CHANNEL
