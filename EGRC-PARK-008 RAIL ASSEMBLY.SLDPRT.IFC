Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-008 RAIL ASSEMBLY.SLDPRT.IFC
Time: 2024-12-17T11:44:26+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 26.1899519999998276; Volume Measure: 0.0261899519999998; Area Measure: 5.8051222159236779

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 26.1899519999998276; Volume Measure: 0.0261899519999998; Area Measure: 5.8051222159236779

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 26.1899519999998276; Volume Measure: 0.0261899519999998; Area Measure: 5.8051222159236779

# IfcBuildingElementProxy (13)
In: default BuildingStorey
Name
EGRC-PARK-008 RAIL ASSEMBLY.SLDPRT | PSet_Mass_Property - Mass Measure: 26.1899519999998276; Volume Measure: 0.0261899519999998; Area Measure: 5.8051222159236779
EGRC-PARK-015 CENTRAL CHANNEL | SOLIDWORKS Custom Properties - Description: CENTRAL CHANNEL; PartNo: EGRC-PARK-015; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
EGRC-PARK-008 CROSS CHANNEL PLATE
EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE
EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-1
EGRC-PARK-008 CROSS CHANNEL PLATE-1
EGRC-PARK-008 CROSS CHANNEL PLATE-2
EGRC-PARK-008 CROSS CHANNEL PLATE-3
EGRC-PARK-008 CROSS CHANNEL PLATE-4
EGRC-PARK-008 CROSS CHANNEL PLATE-5
EGRC-PARK-008 CROSS CHANNEL PLATE-6
EGRC-PARK-008 CROSS CHANNEL PLATE-7
EGRC-PARK-008 CROSS CHANNEL PLATE-8
