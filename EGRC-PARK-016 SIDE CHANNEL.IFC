Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-016 SIDE CHANNEL.IFC
Time: 2024-12-17T11:14:24+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 11.6017280000001115; Volume Measure: 0.0116017280000001; Area Measure: 2.5827051426239223

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 11.6017280000001115; Volume Measure: 0.0116017280000001; Area Measure: 2.5827051426239223

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 11.6017280000001115; Volume Measure: 0.0116017280000001; Area Measure: 2.5827051426239223

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-PARK-016 SIDE CHANNEL | PSet_Mass_Property - Mass Measure: 11.6017280000001115; Volume Measure: 0.0116017280000001; Area Measure: 2.5827051426239223
EGRC-PARK-016 SIDE CHANNEL
