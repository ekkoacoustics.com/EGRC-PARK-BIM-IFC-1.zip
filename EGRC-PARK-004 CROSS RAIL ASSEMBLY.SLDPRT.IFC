Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-004 CROSS RAIL ASSEMBLY.SLDPRT.IFC
Time: 2024-12-17T11:49:52+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 7.7297280000001010; Volume Measure: 0.0077297280000001; Area Measure: 1.7121301816697725

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 7.7297280000001010; Volume Measure: 0.0077297280000001; Area Measure: 1.7121301816697725

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 7.7297280000001010; Volume Measure: 0.0077297280000001; Area Measure: 1.7121301816697725

# IfcBuildingElementProxy (8)
In: default BuildingStorey
Name
EGRC-PARK-004 CROSS RAIL ASSEMBLY.SLDPRT | PSet_Mass_Property - Mass Measure: 7.7297280000001010; Volume Measure: 0.0077297280000001; Area Measure: 1.7121301816697725
EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE
EGRC-PARK-006 CROSS CHANNEL
EGRC-PARK-008 CROSS CHANNEL PLATE
EGRC-PARK-008 CROSS CHANNEL PLATE-1
EGRC-PARK-006 CROSS CHANNEL-1
EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-1
EGRC-PARK-006 CROSS CHANNEL-2
