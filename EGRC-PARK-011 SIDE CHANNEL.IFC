Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-011 SIDE CHANNEL.IFC
Time: 2024-12-17T11:20:04+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 6.1936000000000657; Volume Measure: 0.0061936000000001; Area Measure: 1.3736384414312313

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 6.1936000000000657; Volume Measure: 0.0061936000000001; Area Measure: 1.3736384414312313

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 6.1936000000000657; Volume Measure: 0.0061936000000001; Area Measure: 1.3736384414312313

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-PARK-011 SIDE CHANNEL | PSet_Mass_Property - Mass Measure: 6.1936000000000657; Volume Measure: 0.0061936000000001; Area Measure: 1.3736384414312313
EGRC-PARK-011 SIDE CHANNEL
