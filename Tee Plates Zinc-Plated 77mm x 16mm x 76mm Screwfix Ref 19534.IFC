Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534.IFC
Time: 2024-12-17T11:05:56+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 0.0039434439902116; Volume Measure: 0.0000039434439902; Area Measure: 0.0048632733766114

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 0.0039434439902116; Volume Measure: 0.0000039434439902; Area Measure: 0.0048632733766114

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 0.0039434439902116; Volume Measure: 0.0000039434439902; Area Measure: 0.0048632733766114

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534 | PSet_Mass_Property - Mass Measure: 0.0039434439902116; Volume Measure: 0.0000039434439902; Area Measure: 0.0048632733766114
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534
