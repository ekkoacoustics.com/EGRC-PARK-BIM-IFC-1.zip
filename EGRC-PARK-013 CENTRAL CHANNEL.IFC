Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-013 CENTRAL CHANNEL.IFC
Time: 2024-12-17T11:17:52+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 6.1925760000000079; Volume Measure: 0.0061925760000000; Area Measure: 1.4019447617492791

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 6.1925760000000079; Volume Measure: 0.0061925760000000; Area Measure: 1.4019447617492791

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 6.1925760000000079; Volume Measure: 0.0061925760000000; Area Measure: 1.4019447617492791

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-PARK-013 CENTRAL CHANNEL | PSet_Mass_Property - Mass Measure: 6.1925760000000079; Volume Measure: 0.0061925760000000; Area Measure: 1.4019447617492791
EGRC-PARK-013 CENTRAL CHANNEL
