Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-001 CROSS RAIL ASSEMBLY.SLDPRT.IFC
Time: 2024-12-17T14:46:29+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 5.1688320000000516; Volume Measure: 0.0051688320000001; Area Measure: 1.1470361211131803

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 5.1688320000000516; Volume Measure: 0.0051688320000001; Area Measure: 1.1470361211131803

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 5.1688320000000516; Volume Measure: 0.0051688320000001; Area Measure: 1.1470361211131803

# IfcBuildingElementProxy (6)
In: default BuildingStorey
Name
EGRC-PARK-001 CROSS RAIL ASSEMBLY.SLDPRT | PSet_Mass_Property - Mass Measure: 5.1688320000000516; Volume Measure: 0.0051688320000001; Area Measure: 1.1470361211131803
EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE
EGRC-PARK-006 CROSS CHANNEL
EGRC-PARK-006 CROSS CHANNEL-1
EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-1
EGRC-PARK-008 CROSS CHANNEL PLATE
