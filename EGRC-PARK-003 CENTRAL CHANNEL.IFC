Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-003 CENTRAL CHANNEL.IFC
Time: 2024-12-17T11:26:48+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 8.2765440000000119; Volume Measure: 0.0082765440000000; Area Measure: 1.8743461123456233

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 8.2765440000000119; Volume Measure: 0.0082765440000000; Area Measure: 1.8743461123456233

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 8.2765440000000119; Volume Measure: 0.0082765440000000; Area Measure: 1.8743461123456233

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGRC-PARK-003 CENTRAL CHANNEL | PSet_Mass_Property - Mass Measure: 8.2765440000000119; Volume Measure: 0.0082765440000000; Area Measure: 1.8743461123456233
EGRC-PARK-003 CENTRAL CHANNEL
