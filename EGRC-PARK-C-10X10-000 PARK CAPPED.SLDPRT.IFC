Properties of the parts of a building model (IFC4), part 2 of 2

# IfcBuildingElementProxy (1244)
Name
3.5mm Wood Screw Cross Head-398 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-399 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-400 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-401 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-402 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-403 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-404 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-405 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-406 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-407 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-408 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-409 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-410 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-411 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-412 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-413 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-414 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-415 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-416 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-417 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-418 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-419 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-420 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-421 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-422 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-423 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-424 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-425 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-426 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-427 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-428 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-429 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-430 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-431 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-432 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-433 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-434 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-435 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-436 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-437 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-438 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-439 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-440 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-441 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-442 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-443 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-444 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-445 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-446 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-447 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-448 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-449 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-450 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-451 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-452 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-453 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-454 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-455 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-456 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-8
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-9
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-10
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-11
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-12
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-13
3.5mm Wood Screw Cross Head-457 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-14
3.5mm Wood Screw Cross Head-458 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-15
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-16
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-17
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-18
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-19
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-20
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-21
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-22
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-23
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-24
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-25
3.5mm Wood Screw Cross Head-459 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-460 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-26
3.5mm Wood Screw Cross Head-461 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-462 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-27
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-28
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-29
3.5mm Wood Screw Cross Head-463 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-30
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-31
3.5mm Wood Screw Cross Head-464 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-465 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-466 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-467 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-83
3.5mm Wood Screw Cross Head-468 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-469 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-84
3.5mm Wood Screw Cross Head-470 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-471 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-472 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-85
3.5mm Wood Screw Cross Head-473 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-474 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-475 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-476 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496-1
3.5mm Wood Screw Cross Head-477 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496-2
3.5mm Wood Screw Cross Head-478 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-479 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-480 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-481 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-32
3.5mm Wood Screw Cross Head-482 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-483 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-484 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-33
3.5mm Wood Screw Cross Head-485 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-486 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-487 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-488 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-489 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-34
3.5mm Wood Screw Cross Head-490 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-491 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-492 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-493 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-494 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-495 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-496 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-497 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-498 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-499 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-500 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-501 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-502 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-503 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-504 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-505 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-506 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-507 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-508 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-509 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-510 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-511 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-512 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-513 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-514 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-515 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-516 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-517 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-518 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-519 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-520 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-521 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-522 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-523 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-524 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-525 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-526 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-527 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-528 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-529 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-530 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
EGRC-PARK-010 CAPPING PANEL-22
EGRC-PARK-010 CAPPING PANEL-23
EGRC-PARK-010 CAPPING PANEL-24
EGRC-PARK-010 CAPPING PANEL-25
EGRC-PARK-010 CAPPING PANEL-26
EGRC-PARK-010 CAPPING PANEL-27
EGRC-PARK-010 CAPPING PANEL-28
EGRC-PARK-010 CAPPING PANEL-29
EGRC-PARK-010 CAPPING PANEL-30
EGRC-PARK-010 CAPPING PANEL-31
EGRC-PARK-010 CAPPING PANEL-32
EGRC-PARK-010 CAPPING PANEL-33
EGRC-PARK-010 CAPPING PANEL-34
EGRC-PARK-010 CAPPING PANEL-35
EGRC-PARK-010 CAPPING PANEL-36
EGRC-PARK-010 CAPPING PANEL-37
EGRC-PARK-010 CAPPING PANEL-38
EGRC-PARK-010 CAPPING PANEL-39
EGRC-PARK-010 CAPPING PANEL-40
EGRC-PARK-010 CAPPING PANEL-41
EGRC-PARK-010 CAPPING PANEL-42
EGRC-PARK-010 CAPPING PANEL-43
EGRC-PARK-010 CAPPING PANEL-44
EGRC-PARK-010 CAPPING PANEL-45
EGRC-PARK-010 CAPPING PANEL-46
EGRC-PARK-010 CAPPING PANEL-47
EGRC-PARK-010 CAPPING PANEL-48
EGRC-PARK-010 CAPPING PANEL-49
EGRC-PARK-010 CAPPING PANEL-50
EGRC-PARK-010 CAPPING PANEL-51
EGRC-PARK-010 CAPPING PANEL-52
EGRC-PARK-010 CAPPING PANEL-53
EGRC-PARK-010 CAPPING PANEL-54
EGRC-PARK-010 CAPPING PANEL-55
EGRC-PARK-010 CAPPING PANEL-56
EGRC-PARK-010 CAPPING PANEL-57
EGRC-PARK-010 CAPPING PANEL-58
EGRC-PARK-010 CAPPING PANEL-59
EGRC-PARK-010 CAPPING PANEL-60
EGRC-PARK-010 CAPPING PANEL-61
EGRC-PARK-010 CAPPING PANEL-62
EGRC-PARK-010 CAPPING PANEL-63
EGRC-PARK-010 CAPPING PANEL-64
EGRC-PARK-010 CAPPING PANEL-65
EGRC-PARK-010 CAPPING PANEL-66
EGRC-PARK-010 CAPPING PANEL-67
EGRC-PARK-010 CAPPING PANEL-68
EGRC-PARK-010 CAPPING PANEL-69
EGRC-PARK-010 CAPPING PANEL-70
EGRC-PARK-010 CAPPING PANEL-71
EGRC-PARK-010 CAPPING PANEL-72
EGRC-PARK-010 CAPPING PANEL-73
EGRC-PARK-010 CAPPING PANEL-74
EGRC-PARK-010 CAPPING PANEL-75
EGRC-PARK-010 CAPPING PANEL-76
EGRC-PARK-010 CAPPING PANEL-77
EGRC-PARK-010 CAPPING PANEL-78
EGRC-PARK-010 CAPPING PANEL-79
EGRC-PARK-010 CAPPING PANEL-80
EGRC-PARK-010 CAPPING PANEL-81
EGRC-PARK-010 CAPPING PANEL-82
EGRC-PARK-010 CAPPING PANEL-83
EGRC-PARK-010 CAPPING PANEL-84
EGRC-PARK-010 CAPPING PANEL-85
EGRC-PARK-010 CAPPING PANEL-86
EGRC-PARK-010 CAPPING PANEL-87
EGRC-PARK-010 CAPPING PANEL-88
EGRC-PARK-010 CAPPING PANEL-89
EGRC-PARK-010 CAPPING PANEL-90
Wire Cable +Snap Key Hook + Crimping
EGRC-PARK-010 CAPPING PANEL-91
EGRC-PARK-010 CAPPING PANEL-92
EGRC-PARK-010 CAPPING PANEL-93
EGRC-PARK-010 CAPPING PANEL-94
EGRC-PARK-010 CAPPING PANEL-95
EGRC-PARK-010 CAPPING PANEL-96
EGRC-PARK-010 CAPPING PANEL-97
EGRC-PARK-010 CAPPING PANEL-98
Wire Cable +Snap Key Hook + Crimping-1
Wire Cable +Snap Key Hook + Crimping-2
Wire Cable +Snap Key Hook + Crimping-3
Wire Cable +Snap Key Hook + Crimping-4
Wire Cable +Snap Key Hook + Crimping-5
Wire Cable +Snap Key Hook + Crimping-6
Wire Cable +Snap Key Hook + Crimping-7
Wire Cable +Snap Key Hook + Crimping-8
Wire Cable +Snap Key Hook + Crimping-9
Wire Cable +Snap Key Hook + Crimping-10
Wire Cable +Snap Key Hook + Crimping-11
Wire Cable +Snap Key Hook + Crimping-12
Wire Cable +Snap Key Hook + Crimping-13
Wire Cable +Snap Key Hook + Crimping-14
Wire Cable +Snap Key Hook + Crimping-15
Wire Cable +Snap Key Hook + Crimping-16
Wire Cable +Snap Key Hook + Crimping-17
Wire Cable +Snap Key Hook + Crimping-18
Wire Cable +Snap Key Hook + Crimping-19
Wire Cable +Snap Key Hook + Crimping-20
Wire Cable +Snap Key Hook + Crimping-21
Wire Cable +Snap Key Hook + Crimping-22
Wire Cable +Snap Key Hook + Crimping-23
Wire Cable +Snap Key Hook + Crimping-24
Wire Cable +Snap Key Hook + Crimping-25
Wire Cable +Snap Key Hook + Crimping-26
Wire Cable +Snap Key Hook + Crimping-27
Wire Cable +Snap Key Hook + Crimping-28
Wire Cable +Snap Key Hook + Crimping-29
Wire Cable +Snap Key Hook + Crimping-30
Wire Cable +Snap Key Hook + Crimping-31
Wire Cable +Snap Key Hook + Crimping-32
Wire Cable +Snap Key Hook + Crimping-33
Wire Cable +Snap Key Hook + Crimping-34
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-8
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-86
EGRC-PARK-008 RAIL ASSEMBLY.SLDPRT-8
EGRC-PARK-017 SIDE CHANNEL-3 | SOLIDWORKS Custom Properties - sets with these values: 2; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE + ASSEMBLY; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; DESCRIPTION: SIDE CHANNEL; PARTNUMBER: EGRC-PARK-017; REVISION: A
Angle Plates Zinc-Plated 76mm x 76mm x 16.5mm Scewfix Ref 13496-3
3.5mm Wood Screw Cross Head-531 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-87
3.5mm Wood Screw Cross Head-532 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
EGRC-PARK-005 CORNER-3
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-35
3.5mm Wood Screw Cross Head-533 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-534 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-535 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-536 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-88
3.5mm Wood Screw Cross Head-537 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-538 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-539 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-540 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-541 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-542 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-543 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-544 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-545 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-546 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-547 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
CROSS TEE RAIL SECTION-100
3.5mm Wood Screw Cross Head-548 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-549 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Wire Cable +Snap Key Hook + Crimping-35
CROSS TEE RAIL SECTION-101
EGRC-PARK-010 CAPPING PANEL-99
3.5mm Wood Screw Cross Head-550 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-551 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
CROSS TEE RAIL SECTION-102
