Properties of the parts of a building model (IFC4), part 1 of 2

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-C-10X10-000 PARK CAPPED.SLDPRT.IFC
Time: 2024-12-17T16:32:47+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 1269.0002088970709337; Volume Measure: 1.2690002088970689; Area Measure: 297.7525580263934444

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 1269.0002088970709337; Volume Measure: 1.2690002088970689; Area Measure: 297.7525580263934444

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 1269.0002088970709337; Volume Measure: 1.2690002088970689; Area Measure: 297.7525580263934444

# IfcBuildingElementProxy (1244)
In: default BuildingStorey
Name
EGRC-PARK-C-10X10-000 PARK CAPPED.SLDPRT | PSet_Mass_Property - Mass Measure: 1269.0002088970709337; Volume Measure: 1.2690002088970689; Area Measure: 297.7525580263934444
3.5mm Wood Screw Cross Head | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-1 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-2 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-3 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-4 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-5 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-6 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-7 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-8 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-9 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-10 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-11 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-12 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-13 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-14 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-15 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050
3.5mm Wood Screw Cross Head-16 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-17 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-1
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-2
3.5mm Wood Screw Cross Head-18 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-19 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-20 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-21 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-22 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-23 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-24 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-25 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-26 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-27 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-28 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-29 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-30 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-31 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-32 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-33 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-34 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-35 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-36 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-37 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-38 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-39 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-40 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-41 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-42 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-43 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-44 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-45 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-46 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-47 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-48 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-49 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-50 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-51 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-52 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-53 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-54 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-55 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-56 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-57 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-58 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-59 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-60 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-61 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-62 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-63 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-64 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-65 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-66 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-67 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-68 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-69 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-70 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-71 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-72 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-73 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-74 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-75 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-76 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-77 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-78 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-79 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-80 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-81 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-82 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-83 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-84 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-85 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-86 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-87 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-88 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-89 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-90 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-91 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-92 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-93 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-94 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-95 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-96 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-97 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-98 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-99 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-100 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-101 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-102 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-103 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-104 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-105 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-106 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-107 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-108 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-109 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-110 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-111 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-112 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-113 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-114 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-115 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-116 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-117 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-118 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-119 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-120 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-121 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-122 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-123 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-124 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-125 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-126 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-127 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-128 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-129 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-130 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-131 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-132 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-133 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-134 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-135 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-136 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-137 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-138 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-139 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-140 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-141 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-142 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-143 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-144 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-145 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-146 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-147 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-148 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-149 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-150 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-151 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-152 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-153 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-154 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-155 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-156 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-157 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-158 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-159 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-160 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-161 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-162 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-163 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-164 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-165 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-166 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-167 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-168 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-169 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-170 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-171 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-172 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-173 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-174 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-175 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-176 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-177 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-178 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-179 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-180 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-181 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-182 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-183 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-184 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-185 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-186 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-187 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-188 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-189 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-190 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-191 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-192 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-193 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-194 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-195 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-196 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-197 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-198 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-199 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-200 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-201 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-202 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-203 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-204 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-205 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-206 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-207 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-208 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-209 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-210 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-211 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-212 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-213 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-214 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-215 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-216 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-217 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-218 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-219 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-220 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-221 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-222 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-223 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-224 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-225 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-226 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-227 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-228 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-229 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-230 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-231 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-232 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-233 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-234 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-235 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-236 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-237 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-238 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-239 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-240 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-241 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-242 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-243 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-244 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-245 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-246 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-247 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-248 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-249 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-250 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-251 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-252 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-253 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-254 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-255 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-256 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-257 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-258 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-259 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-260 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-261 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-262 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-263 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-264 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-265 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-266 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-267 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-268 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-269 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-270 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-271 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-272 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-273 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-274 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-275 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-276 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-277 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-278 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-279 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-280 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-281 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-282 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-283 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-284 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-285 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-286 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-287 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-288 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-289 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-290 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-291 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-292 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-293 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-294 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-295 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-296 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-297 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-298 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-299 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-300 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-301 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-302 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-303 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-304 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-305 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-306 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-307 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-308 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-309 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-310 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-311 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-312 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-313 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-314 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-315 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-316 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-317 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-318 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-319 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-320 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-321 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-322 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-323 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-324 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-325 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-326 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-327 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-328 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-329 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-330 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-331 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-332 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-333 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-334 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-335 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-336 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-3
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-4
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-5
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-6
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-7
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-8
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-9
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-10
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-11
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-12
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-13
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-14
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-15
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-16
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-17
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-18
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-19
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-20
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-21
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-22
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-23
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-24
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-25
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-26
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-27
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-28
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-29
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-30
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-31
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-32
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-33
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-34
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT
9 x EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE
9 x EGRC-PARK-008 CROSS CHANNEL PLATE
9 x EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-1
9 x EGRC-PARK-006 CROSS CHANNEL
9 x EGRC-PARK-006 CROSS CHANNEL-1
9 x EGRC-PARK-006 CROSS CHANNEL-2
9 x EGRC-PARK-006 CROSS CHANNEL-3
9 x EGRC-PARK-006 CROSS CHANNEL-4
9 x EGRC-PARK-006 CROSS CHANNEL-5
9 x EGRC-PARK-006 CROSS CHANNEL-6
9 x EGRC-PARK-006 CROSS CHANNEL-7
9 x EGRC-PARK-006 CROSS CHANNEL-8
9 x EGRC-PARK-006 CROSS CHANNEL-9
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-1
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-2
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-3
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-4
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-5
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-6
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-7
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-8
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-1
EGRC-PARK-008 RAIL ASSEMBLY.SLDPRT
9 x EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-4
9 x EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-5
9 x EGRC-PARK-015 CENTRAL CHANNEL | SOLIDWORKS Custom Properties - sets with these values: 2; Description: CENTRAL CHANNEL; PartNo: EGRC-PARK-015; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-18
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-19
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-20
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-21
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-22
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-23
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-24
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-25
9 x EGRC-PARK-008 CROSS CHANNEL PLATE-26
EGRC-PARK-008 RAIL ASSEMBLY.SLDPRT-1
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-2
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-3
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-4
EGRC-PARK-008 RAIL ASSEMBLY.SLDPRT-2
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-5
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-6
EGRC-PARK-006 CROSS RAIL ASSEMBLY.SLDPRT-7
EGRC-PARK-008 RAIL ASSEMBLY.SLDPRT-3
EGRC-PARK-008 RAIL ASSEMBLY.SLDPRT-4
EGRC-PARK-008 RAIL ASSEMBLY.SLDPRT-5
EGRC-PARK-017 SIDE CHANNEL | SOLIDWORKS Custom Properties - sets with these values: 2; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE + ASSEMBLY; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; DESCRIPTION: SIDE CHANNEL; PARTNUMBER: EGRC-PARK-017; REVISION: A
EGRC-PARK-008 RAIL ASSEMBLY.SLDPRT-6
3.5mm Wood Screw Cross Head-337 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
EGRC-PARK-017 SIDE CHANNEL-1 | SOLIDWORKS Custom Properties - sets with these values: 2; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE + ASSEMBLY; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; DESCRIPTION: SIDE CHANNEL; PARTNUMBER: EGRC-PARK-017; REVISION: A
EGRC-PARK-005 CORNER
3.5mm Wood Screw Cross Head-338 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
EGRC-PARK-005 CORNER-1
3.5mm Wood Screw Cross Head-339 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-340 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
EGRC-PARK-008 RAIL ASSEMBLY.SLDPRT-7
EGRC-PARK-005 CORNER-2
EGRC-PARK-017 SIDE CHANNEL-2 | SOLIDWORKS Custom Properties - sets with these values: 2; Material: 12MM EKKO ACOUSTIC PANEL; Finish: CUT TO SHAPE + ASSEMBLY; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; DESCRIPTION: SIDE CHANNEL; PARTNUMBER: EGRC-PARK-017; REVISION: A
3.5mm Wood Screw Cross Head-341 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-342 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-343 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-344 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-345 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-346 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-347 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-348 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-349 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-350 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-351 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-352 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-353 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-354 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-355 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-356 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-357 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-358 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-359 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-360 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-361 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-362 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-363 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-364 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-365 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-366 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-367 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534
3.5mm Wood Screw Cross Head-368 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-369 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-370 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-1
3.5mm Wood Screw Cross Head-371 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-372 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-373 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-374 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-375 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-376 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-3
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-4
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-5
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-6
3.5mm Wood Screw Cross Head-377 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
Tee Plates Zinc-Plated 77mm x 16mm x 76mm Screwfix Ref 19534-7
3.5mm Wood Screw Cross Head-378 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
CROSS TEE RAIL SECTION
CROSS TEE RAIL SECTION-1
CROSS TEE RAIL SECTION-2
CROSS TEE RAIL SECTION-3
CROSS TEE RAIL SECTION-4
CROSS TEE RAIL SECTION-5
CROSS TEE RAIL SECTION-6
CROSS TEE RAIL SECTION-7
CROSS TEE RAIL SECTION-8
CROSS TEE RAIL SECTION-9
CROSS TEE RAIL SECTION-10
CROSS TEE RAIL SECTION-11
CROSS TEE RAIL SECTION-12
CROSS TEE RAIL SECTION-13
CROSS TEE RAIL SECTION-14
CROSS TEE RAIL SECTION-15
CROSS TEE RAIL SECTION-16
CROSS TEE RAIL SECTION-17
CROSS TEE RAIL SECTION-18
CROSS TEE RAIL SECTION-19
CROSS TEE RAIL SECTION-20
CROSS TEE RAIL SECTION-21
CROSS TEE RAIL SECTION-22
CROSS TEE RAIL SECTION-23
CROSS TEE RAIL SECTION-24
CROSS TEE RAIL SECTION-25
EGRC-PARK-010 CAPPING PANEL
EGRC-PARK-010 CAPPING PANEL-1
EGRC-PARK-010 CAPPING PANEL-2
EGRC-PARK-010 CAPPING PANEL-3
EGRC-PARK-010 CAPPING PANEL-4
EGRC-PARK-010 CAPPING PANEL-5
EGRC-PARK-010 CAPPING PANEL-6
EGRC-PARK-010 CAPPING PANEL-7
EGRC-PARK-010 CAPPING PANEL-8
EGRC-PARK-010 CAPPING PANEL-9
EGRC-PARK-010 CAPPING PANEL-10
EGRC-PARK-010 CAPPING PANEL-11
EGRC-PARK-010 CAPPING PANEL-12
EGRC-PARK-010 CAPPING PANEL-13
EGRC-PARK-010 CAPPING PANEL-14
EGRC-PARK-010 CAPPING PANEL-15
EGRC-PARK-010 CAPPING PANEL-16
EGRC-PARK-010 CAPPING PANEL-17
EGRC-PARK-010 CAPPING PANEL-18
EGRC-PARK-010 CAPPING PANEL-19
EGRC-PARK-010 CAPPING PANEL-20
EGRC-PARK-010 CAPPING PANEL-21
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-35
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-36
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-37
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-38
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-39
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-40
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-41
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-42
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-43
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-44
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-45
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-46
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-47
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-48
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-49
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-50
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-51
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-52
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-53
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-54
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-55
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-56
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-57
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-58
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-59
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-60
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-61
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-62
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-63
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-64
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-65
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-66
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-67
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-68
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-69
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-70
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-71
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-72
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-73
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-74
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-75
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-76
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-77
CROSS TEE RAIL SECTION-26
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-78
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-79
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-80
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-81
Mending Plates Zinc-Plated 100mm x 16mm Screwfix Ref 16050-82
CROSS TEE RAIL SECTION-27
CROSS TEE RAIL SECTION-28
CROSS TEE RAIL SECTION-29
CROSS TEE RAIL SECTION-30
CROSS TEE RAIL SECTION-31
CROSS TEE RAIL SECTION-32
CROSS TEE RAIL SECTION-33
CROSS TEE RAIL SECTION-34
CROSS TEE RAIL SECTION-35
CROSS TEE RAIL SECTION-36
CROSS TEE RAIL SECTION-37
CROSS TEE RAIL SECTION-38
CROSS TEE RAIL SECTION-39
CROSS TEE RAIL SECTION-40
CROSS TEE RAIL SECTION-41
CROSS TEE RAIL SECTION-42
CROSS TEE RAIL SECTION-43
CROSS TEE RAIL SECTION-44
CROSS TEE RAIL SECTION-45
CROSS TEE RAIL SECTION-46
CROSS TEE RAIL SECTION-47
CROSS TEE RAIL SECTION-48
CROSS TEE RAIL SECTION-49
CROSS TEE RAIL SECTION-50
CROSS TEE RAIL SECTION-51
CROSS TEE RAIL SECTION-52
CROSS TEE RAIL SECTION-53
CROSS TEE RAIL SECTION-54
CROSS TEE RAIL SECTION-55
CROSS TEE RAIL SECTION-56
CROSS TEE RAIL SECTION-57
CROSS TEE RAIL SECTION-58
CROSS TEE RAIL SECTION-59
CROSS TEE RAIL SECTION-60
CROSS TEE RAIL SECTION-61
CROSS TEE RAIL SECTION-62
CROSS TEE RAIL SECTION-63
CROSS TEE RAIL SECTION-64
CROSS TEE RAIL SECTION-65
CROSS TEE RAIL SECTION-66
CROSS TEE RAIL SECTION-67
CROSS TEE RAIL SECTION-68
CROSS TEE RAIL SECTION-69
CROSS TEE RAIL SECTION-70
CROSS TEE RAIL SECTION-71
CROSS TEE RAIL SECTION-72
CROSS TEE RAIL SECTION-73
CROSS TEE RAIL SECTION-74
CROSS TEE RAIL SECTION-75
CROSS TEE RAIL SECTION-76
CROSS TEE RAIL SECTION-77
CROSS TEE RAIL SECTION-78
CROSS TEE RAIL SECTION-79
CROSS TEE RAIL SECTION-80
CROSS TEE RAIL SECTION-81
CROSS TEE RAIL SECTION-82
CROSS TEE RAIL SECTION-83
CROSS TEE RAIL SECTION-84
CROSS TEE RAIL SECTION-85
CROSS TEE RAIL SECTION-86
CROSS TEE RAIL SECTION-87
CROSS TEE RAIL SECTION-88
CROSS TEE RAIL SECTION-89
CROSS TEE RAIL SECTION-90
CROSS TEE RAIL SECTION-91
CROSS TEE RAIL SECTION-92
CROSS TEE RAIL SECTION-93
CROSS TEE RAIL SECTION-94
CROSS TEE RAIL SECTION-95
CROSS TEE RAIL SECTION-96
CROSS TEE RAIL SECTION-97
CROSS TEE RAIL SECTION-98
CROSS TEE RAIL SECTION-99
3.5mm Wood Screw Cross Head-379 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-380 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-381 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-382 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-383 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-384 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-385 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-386 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-387 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-388 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-389 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-390 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-391 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-392 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-393 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-394 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-395 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-396 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
3.5mm Wood Screw Cross Head-397 | SOLIDWORKS Custom Properties - UNIT_OF_MEASURE: - none -; sets with these values: 2
