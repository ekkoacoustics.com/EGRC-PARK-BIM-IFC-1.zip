Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Park\EGRC-PARK-005 CROSS RAIL ASSEMBLY.SLDPRT.IFC
Time: 2024-12-17T11:48:58+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 12.8515200000001997; Volume Measure: 0.0128515200000002; Area Measure: 2.8423183027829566

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 12.8515200000001997; Volume Measure: 0.0128515200000002; Area Measure: 2.8423183027829566

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 12.8515200000001997; Volume Measure: 0.0128515200000002; Area Measure: 2.8423183027829566

# IfcBuildingElementProxy (12)
In: default BuildingStorey
Name
EGRC-PARK-005 CROSS RAIL ASSEMBLY.SLDPRT | PSet_Mass_Property - Mass Measure: 12.8515200000001997; Volume Measure: 0.0128515200000002; Area Measure: 2.8423183027829566
EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE
EGRC-PARK-006 CROSS CHANNEL
EGRC-PARK-008 CROSS CHANNEL PLATE
EGRC-PARK-006 CROSS CHANNEL-1
EGRC-PARK-006 CROSS CHANNEL-2
EGRC-PARK-008 CROSS CHANNEL PLATE-1
EGRC-PARK-009 CROSS CHANNEL END FIXING PLATE-1
EGRC-PARK-006 CROSS CHANNEL-3
EGRC-PARK-008 CROSS CHANNEL PLATE-2
EGRC-PARK-008 CROSS CHANNEL PLATE-3
EGRC-PARK-006 CROSS CHANNEL-4
